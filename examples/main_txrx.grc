options:
  parameters:
    author: jp
    generate_options: no_gui
    id: main_txrx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: alphaPower
  id: variable
  parameters:
    value: '0.1'
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '16'
  states: {}
- name: detectionDecim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: maxFrameTime
  id: variable
  parameters:
    value: (2**(12)/BW)*(5 + 8 + 257*2*8/12)
  states: {state: disabled}
- name: powerDecim
  id: variable
  parameters:
    value: '10'
  states: {state: disabled}
- name: powerThreshold
  id: variable
  parameters:
    value: '5e-3'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '400'
  states: {}
- name: LibreLoRa_LoRaPDUHeaderGenerator_0
  id: LibreLoRa_LoRaPDUHeaderGenerator
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LibreLoRa_LoRaPDUHeaderGenerator_0_0
  id: LibreLoRa_LoRaPDUHeaderGenerator
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LibreLoRa_LoRaPDUHeaderGenerator_0_0_0
  id: LibreLoRa_LoRaPDUHeaderGenerator
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0
  id: LibreLoRa_LoRaPDUHeaderGenerator
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0
  id: LibreLoRa_LoRaPDUHeaderGenerator
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0_0
  id: LibreLoRa_LoRaPDUHeaderGenerator
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LibreLoRa_LoRaPDUHeaderReader_0
  id: LibreLoRa_LoRaPDUHeaderReader
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LibreLoRa_PowerDetector_0
  id: LibreLoRa_PowerDetector
  parameters:
    decimation: powerDecim
    message: pmt.PMT_NIL
    minoutbuf: 2*int(maxFrameTime*samp_rate)
    samp_rate: samp_rate
    threshold: powerThreshold
    timeout: maxFrameTime*10
  states: {state: disabled}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '12'
    decimation: decimation
    detectionDecim: detectionDecim
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '11'
    decimation: decimation
    detectionDecim: detectionDecim
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '10'
    decimation: decimation
    detectionDecim: detectionDecim
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '9'
    decimation: decimation
    detectionDecim: detectionDecim
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '8'
    decimation: decimation
    detectionDecim: detectionDecim
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '7'
    decimation: decimation
    detectionDecim: detectionDecim
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaTx_0
  id: LoRaTx
  parameters:
    BW: 125e3
    CR: '1'
    CRCPresent: 'True'
    SF: '8'
    lowDataRate: 'False'
    nUpchirps: '5'
    payloadSize: '8'
    samp_rate: samp_rate_tx
    syncwordNumber: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_tx
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '1202'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0_0_0_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: (1, -alphaPower)
    fftaps: (1 - alphaPower)
    oldstyle: 'False'
    type: ffd
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: center_freq
    gain0: '13'
    if_gain0: '15'
    sample_rate: samp_rate_tx
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: soapy=0,driver=hackrf
    bb_gain0: '26'
    clock_source0: internal
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 2**13
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: powerDecim
    interp: '1'
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '0'
    freq0: center_freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LibreLoRa_LoRaPDUHeaderGenerator_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [LibreLoRa_LoRaPDUHeaderGenerator_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [LibreLoRa_LoRaPDUHeaderGenerator_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0, '0']
- [LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0_0, '0']
- [LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0_0_0, '0']
- [LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0_0, '0', blocks_tagged_stream_to_pdu_0_0_0_0_0_0, '0']
- [LibreLoRa_LoRaPDUHeaderReader_0, '0', LoRaTx_0, '0']
- [LibreLoRa_LoRaPDUHeaderReader_0, freq, analog_sig_source_x_0, freq]
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0_0_0_0, '0']
- [LoRaRx_0, '0', LibreLoRa_LoRaPDUHeaderGenerator_0, '0']
- [LoRaRx_0, detectionOut, LibreLoRa_LoRaPDUHeaderGenerator_0, detectionIn]
- [LoRaRx_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0, '0', LibreLoRa_LoRaPDUHeaderGenerator_0_0, '0']
- [LoRaRx_0_0, detectionOut, LibreLoRa_LoRaPDUHeaderGenerator_0_0, detectionIn]
- [LoRaRx_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0, '0', LibreLoRa_LoRaPDUHeaderGenerator_0_0_0, '0']
- [LoRaRx_0_0_0, detectionOut, LibreLoRa_LoRaPDUHeaderGenerator_0_0_0, detectionIn]
- [LoRaRx_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0, '0', LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0, '0']
- [LoRaRx_0_0_0_0, detectionOut, LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0, detectionIn]
- [LoRaRx_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0_0, '0', LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0, detectionOut, LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0, detectionIn]
- [LoRaRx_0_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0_0_0, '0', LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0_0, detectionOut, LibreLoRa_LoRaPDUHeaderGenerator_0_0_0_0_0_0, detectionIn]
- [LoRaRx_0_0_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaTx_0, '0', blocks_multiply_xx_0, '0']
- [LoRaTx_0, '0', osmosdr_sink_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_squared_0_1, '0', iir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', LibreLoRa_LoRaPDUHeaderReader_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_0_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_0_0_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_0_0_0_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_0_0_0_0_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_tagged_stream_to_pdu_0_0_0_0_0_0, pdus, blocks_socket_pdu_0, pdus]
- [iir_filter_xxx_0, '0', LibreLoRa_PowerDetector_0, '1']
- [osmosdr_source_0, '0', LibreLoRa_PowerDetector_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [rtlsdr_source_0, '0', LibreLoRa_PowerDetector_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
