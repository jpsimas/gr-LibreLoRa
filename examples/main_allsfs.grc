options:
  parameters:
    author: jp
    generate_options: no_gui
    id: main2
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '400'
  states: {}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '12'
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '11'
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '10'
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '9'
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '8'
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '7'
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1212'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1211'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1210'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1209'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1208'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1207'
    type: byte
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: '433e6 '
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [LoRaRx_0, '0', blocks_tcp_server_sink_0, '0']
- [LoRaRx_0, '1', blocks_null_sink_0, '0']
- [LoRaRx_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0, '0', blocks_tcp_server_sink_0_0, '0']
- [LoRaRx_0_0, '1', blocks_null_sink_0_0, '0']
- [LoRaRx_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0, '0', blocks_tcp_server_sink_0_0_0, '0']
- [LoRaRx_0_0_0, '1', blocks_null_sink_0_0_0, '0']
- [LoRaRx_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0_0, '0', blocks_tcp_server_sink_0_0_0_0, '0']
- [LoRaRx_0_0_0_0, '1', blocks_null_sink_0_0_0_0, '0']
- [LoRaRx_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0_0_0, '0', blocks_tcp_server_sink_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0, '1', blocks_null_sink_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0_0_0_0, '0', blocks_tcp_server_sink_0_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0_0, '1', blocks_null_sink_0_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [rtlsdr_source_0, '0', LoRaRx_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0_0_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0_0_0_0_0_0, '0']

metadata:
  file_format: 1
