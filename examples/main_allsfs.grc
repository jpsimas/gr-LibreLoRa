options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: main_allsfs
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: alphaPower
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 919e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: maxFrameTime
  id: variable
  parameters:
    value: (2**(12)/BW)*(5 + 8 + 257*2*8/12)
  states: {}
- name: powerDecim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: powerThreshold
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '400'
  states: {}
- name: LibreLoRa_PowerDetector_0
  id: LibreLoRa_PowerDetector
  parameters:
    decimation: powerDecim
    message: pmt.PMT_NIL
    minoutbuf: 2*int(maxFrameTime*samp_rate)
    samp_rate: samp_rate
    threshold: powerThreshold
    timeout: maxFrameTime*1.5
  states: {}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '12'
    decimation: decimation
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '11'
    decimation: decimation
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '10'
    decimation: decimation
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '9'
    decimation: decimation
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '8'
    decimation: decimation
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: LoRaRx_0_0_0_0_0_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: '7'
    decimation: decimation
    detectorThreshold: threshold
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1212'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1211'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1210'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1209'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1208'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_tcp_server_sink_0_0_0_0_0_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1207'
    type: byte
    vlen: '1'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: (1, -alphaPower)
    fftaps: (1 - alphaPower)
    oldstyle: 'False'
    type: ffd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '6'
    clock_source0: internal
    freq0: center_freq
    gain0: '14'
    gain_mode0: 'False'
    if_gain0: '16'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: powerDecim
    interp: '1'
    taps: '[1]'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: center_freq
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0_0_0, '0']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0_0_0_0_0_0, '0']
- [LoRaRx_0, '0', blocks_tcp_server_sink_0, '0']
- [LoRaRx_0, '1', blocks_null_sink_0, '0']
- [LoRaRx_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0, '0', blocks_tcp_server_sink_0_0, '0']
- [LoRaRx_0_0, '1', blocks_null_sink_0_0, '0']
- [LoRaRx_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0, '0', blocks_tcp_server_sink_0_0_0, '0']
- [LoRaRx_0_0_0, '1', blocks_null_sink_0_0_0, '0']
- [LoRaRx_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0_0, '0', blocks_tcp_server_sink_0_0_0_0, '0']
- [LoRaRx_0_0_0_0, '1', blocks_null_sink_0_0_0_0, '0']
- [LoRaRx_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0_0_0, '0', blocks_tcp_server_sink_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0, '1', blocks_null_sink_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [LoRaRx_0_0_0_0_0_0, '0', blocks_tcp_server_sink_0_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0_0, '1', blocks_null_sink_0_0_0_0_0_0, '0']
- [LoRaRx_0_0_0_0_0_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0_0_0_0_0_0, detectionOut, zeromq_pub_msg_sink_0, in]
- [blocks_complex_to_mag_squared_0_1, '0', iir_filter_xxx_0, '0']
- [iir_filter_xxx_0, '0', LibreLoRa_PowerDetector_0, '1']
- [osmosdr_source_0, '0', LibreLoRa_PowerDetector_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [rtlsdr_source_0, '0', LibreLoRa_PowerDetector_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
