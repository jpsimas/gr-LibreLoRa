options:
  parameters:
    author: jp
    generate_options: no_gui
    id: LoRaDetector
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: detectionDecim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '300'
  states: {}
- name: LibreLoRa_ChirpDetector_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: 125e3
    DFTDecim: detectionDecim
    DFTSize: None
    SF: '7'
    samp_rate: samp_rate
    threshold: threshold
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_0_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: 125e3
    DFTDecim: detectionDecim
    DFTSize: None
    SF: '8'
    samp_rate: samp_rate
    threshold: threshold
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_1
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTDecim: detectionDecim
    DFTSize: None
    SF: '9'
    samp_rate: samp_rate
    threshold: threshold
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_2
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTDecim: detectionDecim
    DFTSize: None
    SF: '10'
    samp_rate: samp_rate
    threshold: threshold
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_2_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTDecim: detectionDecim
    DFTSize: None
    SF: '11'
    samp_rate: samp_rate
    threshold: threshold
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_2_0_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTDecim: detectionDecim
    DFTSize: None
    SF: '12'
    samp_rate: samp_rate
    threshold: threshold
    timeout: '5'
  states: {}
- name: LibreLoRa_DetectionCount_0
  id: LibreLoRa_DetectionCount
  parameters:
    BW: BW
    channelWidth: 200e3
    nChannels: '5'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: '10000'
    port: '1202'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LibreLoRa_ChirpDetector_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_0, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_0_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_0_0, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_1, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_1, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_2, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_2, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_2_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_2_0_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_2_0_0, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_DetectionCount_0, count, blocks_message_debug_0, print]
- [LibreLoRa_DetectionCount_0, count, blocks_socket_pdu_0, pdus]
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_0, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_0_0, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_1, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_2, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_2_0, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_2_0_0, '0']

metadata:
  file_format: 1
