options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: LoRaDetector
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: LibreLoRa_ChirpDetector_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: 125e3
    DFTSize: None
    SF: '7'
    samp_rate: samp_rate
    threshold: '0.2'
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_0_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: 125e3
    DFTSize: None
    SF: '8'
    samp_rate: samp_rate
    threshold: '0.2'
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_1
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTSize: None
    SF: '9'
    samp_rate: samp_rate
    threshold: '0.2'
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_2
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTSize: None
    SF: '10'
    samp_rate: samp_rate
    threshold: '0.2'
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_2_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTSize: None
    SF: '11'
    samp_rate: samp_rate
    threshold: '0.2'
    timeout: '5'
  states: {}
- name: LibreLoRa_ChirpDetector_2_0_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTSize: None
    SF: '12'
    samp_rate: samp_rate
    threshold: '0.2'
    timeout: '5'
  states: {}
- name: LibreLoRa_DetectionCount_0
  id: LibreLoRa_DetectionCount
  parameters:
    BW: BW
    nChannels: '3'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 433e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LibreLoRa_ChirpDetector_0, '0', blocks_null_sink_0, '0']
- [LibreLoRa_ChirpDetector_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_0, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_0_0, '0', blocks_null_sink_1, '0']
- [LibreLoRa_ChirpDetector_0_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_0_0, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_1, '0', blocks_null_sink_1_0, '0']
- [LibreLoRa_ChirpDetector_1, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_1, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_2, '0', blocks_null_sink_1_0_0, '0']
- [LibreLoRa_ChirpDetector_2, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_2, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_ChirpDetector_2_0, '0', blocks_null_sink_1_0_0_0, '0']
- [LibreLoRa_ChirpDetector_2_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_2_0_0, '0', blocks_null_sink_1_0_0_0_0, '0']
- [LibreLoRa_ChirpDetector_2_0_0, detectOut, LibreLoRa_DetectionCount_0, detectionMessage]
- [LibreLoRa_ChirpDetector_2_0_0, detectOut, blocks_message_debug_0, print]
- [LibreLoRa_DetectionCount_0, count, blocks_message_debug_0, print]
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_0, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_0_0, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_1, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_2, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_2_0, '0']
- [rtlsdr_source_0, '0', LibreLoRa_ChirpDetector_2_0_0, '0']

metadata:
  file_format: 1
