options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: newdemodtest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/BW)
  states: {}
- name: SF
  id: variable
  parameters:
    value: '7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: LibreLoRa_chirpSource_0
  id: LibreLoRa_chirpSource
  parameters:
    SF: SF
    symbolSize: symbolSize
  states: {}
- name: LibreLoRa_chirpSource_0_0
  id: LibreLoRa_chirpSource
  parameters:
    SF: '8'
    symbolSize: symbolSize
  states: {}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    mu: 0.05/OSF
  states: {}
- name: LibreLoRa_frequencyTracker_0_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    mu: 0.5/OSF
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_1
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(symbolSize/4)
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_exponentiate_const_cci_0
  id: blocks_exponentiate_const_cci
  parameters:
    exponent: OSF
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jp/Polito/Thesis/lorasim-matlab/sample_data/out_sdr_sf7_fs1000k_length_7bytes_onehot_counting.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 0.1*BW/2
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"frequencyTracker output"'
    size: 10*symbolSize
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: BW/samp_rate
    ymin: '-BW/samp_rate'
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    name: '"frequencyTracker output"'
    size: 10*symbolSize
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"freqchange"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"dechirped"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [LibreLoRa_chirpSource_0, '0', blocks_add_xx_0_0, '0']
- [LibreLoRa_chirpSource_0, '0', blocks_conjugate_cc_1, '0']
- [LibreLoRa_chirpSource_0_0, '0', blocks_add_xx_0, '1']
- [LibreLoRa_chirpSource_0_0, '0', blocks_add_xx_0_0, '1']
- [LibreLoRa_frequencyTracker_0, '0', qtgui_time_sink_x_0, '0']
- [LibreLoRa_frequencyTracker_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0_0, '0', blocks_delay_1, '0']
- [blocks_add_xx_0_0, '0', blocks_exponentiate_const_cci_0, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0_0, '0', blocks_multiply_xx_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '0']
- [blocks_conjugate_cc_0_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_conjugate_cc_1, '0', blocks_delay_0, '0']
- [blocks_delay_0, '0', blocks_multiply_xx_1, '1']
- [blocks_delay_1, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_1_0, '0', blocks_conjugate_cc_0_0, '0']
- [blocks_exponentiate_const_cci_0, '0', LibreLoRa_frequencyTracker_0_0, '0']
- [blocks_file_source_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [blocks_file_source_0, '0', blocks_add_xx_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_delay_1_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_multiply_xx_1, '0', blocks_exponentiate_const_cci_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', LibreLoRa_frequencyTracker_0_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0_1, '0']
- [rtlsdr_source_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
