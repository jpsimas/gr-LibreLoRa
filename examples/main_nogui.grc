options:
  parameters:
    author: jp
    generate_options: no_gui
    id: main_nogui
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW*decimation))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: alphaPower
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: maxFrameTime
  id: variable
  parameters:
    value: (2**(SF)/BW)*(8 + 257*2*8/SF)
  states: {}
- name: powerThreshold
  id: variable
  parameters:
    value: '5e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LibreLoRa_PowerDetector_0_0
  id: LibreLoRa_PowerDetector
  parameters:
    minoutbuf: int(maxFrameTime*samp_rate)
    threshold: powerThreshold
    timeout: 100*symbolSize/samp_rate
  states: {}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: SF
    lowDataRate: 'False'
    samp_rate: samp_rate/decimation
    syncwordNumber: syncwordNumber
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'True'
    port: '1202'
    type: byte
    vlen: '1'
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: (1, -alphaPower)
    fftaps: (1 - alphaPower)
    type: ffd
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: '[1]'
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 433e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LibreLoRa_PowerDetector_0_0, '0', LoRaRx_0, '0']
- [LoRaRx_0, '0', blocks_tcp_server_sink_0, '0']
- [LoRaRx_0, '1', blocks_null_sink_0, '0']
- [LoRaRx_0, reset, LibreLoRa_PowerDetector_0_0, reset]
- [blocks_complex_to_mag_squared_0_1, '0', iir_filter_xxx_0, '0']
- [iir_filter_xxx_0, '0', LibreLoRa_PowerDetector_0_0, '1']
- [rational_resampler_xxx_0, '0', LibreLoRa_PowerDetector_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
