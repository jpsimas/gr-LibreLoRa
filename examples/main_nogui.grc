options:
  parameters:
    author: jp
    generate_options: no_gui
    id: main_nogui
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: SF
    detectorThreshold: '100'
    ignoreLowDataRateRequired: 'False'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: ip_address
    noblock: 'True'
    port: '1202'
    type: byte
    vlen: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 433e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LoRaRx_0, '0', blocks_tcp_server_sink_0, '0']
- [LoRaRx_0, '1', blocks_null_sink_0, '0']
- [rtlsdr_source_0, '0', LoRaRx_0, '0']

metadata:
  file_format: 1
