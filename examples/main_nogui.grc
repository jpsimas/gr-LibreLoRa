options:
  parameters:
    author: jp
    generate_options: no_gui
    id: main_nogui
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: decimationRx
  id: variable
  parameters:
    value: int(symbolSize/128)
  states: {}
- name: ip_address
  id: variable
  parameters:
    value: '''127.0.0.1'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0'
  states: {}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: SF
    decimation: decimationRx
    detectorThreshold: '100'
    ignoreLowDataRateRequired: 'False'
    lowDataRate: 'False'
    samp_rate: samp_rate
    syncwordNumber: syncwordNumber
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: ip_address
    mtu: '10000'
    port: '1202'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 433e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LoRaRx_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [rtlsdr_source_0, '0', LoRaRx_0, '0']

metadata:
  file_format: 1
