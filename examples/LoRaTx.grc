options:
  parameters:
    author: jp
    category: '[Librelora]'
    generate_options: hb
    id: LoRaTx
    output_language: python
    title: LoRa Tx
  states: {}

blocks:
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: SFPayload
  id: variable
  parameters:
    value: SF-2 if lowDataRate else SF
  states: {state: disabled}
- name: nExtraNibbles
  id: variable
  parameters:
    value: (SFPayload - (nPayloadNibbles - (SF - 7))%SFPayload)%SFPayload
  states: {state: disabled}
- name: nPayloadNibbles
  id: variable
  parameters:
    value: 2*(payloadSize + (2 if CRCPresent else 0))
  states: {state: disabled}
- name: nPayloadSymbols
  id: variable
  parameters:
    value: 8 + (nExtraNibbles + nPayloadNibbles)*(CR + 4)/SFPayload
  states: {state: disabled}
- name: preambleFrequency
  id: variable
  parameters:
    value: LibreLoRa.getPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber)
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: int((2**SF)*OSF)
  states: {}
- name: BW
  id: parameter
  parameters:
    label: BW
    value: 125e3
  states: {}
- name: CR
  id: parameter
  parameters:
    label: CR
    value: '1'
  states: {}
- name: CRCPresent
  id: parameter
  parameters:
    label: CRCPresent
    value: 'True'
  states: {}
- name: LibreLoRa_AppendPrefix_0
  id: LibreLoRa_AppendPrefix
  parameters:
    SF: SF
    nUpchirps: nUpchirps
    symbolSize: symbolSize
    syncWordNumber: syncwordNumber
  states: {}
- name: LibreLoRa_AppendSilence_0
  id: LibreLoRa_AppendSilence
  parameters: {}
  states: {}
- name: LibreLoRa_BytesToNibbles_0
  id: LibreLoRa_BytesToNibbles
  parameters: {}
  states: {}
- name: LibreLoRa_CRC16_0
  id: LibreLoRa_CRC16
  parameters:
    payloadsize: payloadSize
    polynomial: '0x1021'
    xorout: '0'
  states: {}
- name: LibreLoRa_Encode_0
  id: LibreLoRa_Encode
  parameters:
    CR: CR
  states: {}
- name: LibreLoRa_FrequencyMod_0
  id: LibreLoRa_FrequencyMod
  parameters: {}
  states: {}
- name: LibreLoRa_GrayDecode_0
  id: LibreLoRa_GrayDecode
  parameters:
    nBits: SF
  states: {}
- name: LibreLoRa_Interleave_0
  id: LibreLoRa_Interleave
  parameters:
    CR: CR
    SF: SF
  states: {}
- name: LibreLoRa_SymbolMod_0
  id: LibreLoRa_SymbolMod
  parameters:
    SF: SF
    symbolSize: symbolSize
  states: {}
- name: LibreLoRa_TransmitterController_0
  id: LibreLoRa_TransmitterController
  parameters:
    CR: CR
    CRCpresent: CRCPresent
    SF: SF
    lowDataRate: lowDataRate
    payloadSize: payloadSize
    symbolSize: symbolSize
  states: {}
- name: LibreLoRa_randomize_0
  id: LibreLoRa_randomize
  parameters:
    initialState: '255'
    payloadSize: payloadSize
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '8'
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '0xff'
    min: '0'
    num_samps: payloadSize
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: lowDataRate
  id: parameter
  parameters:
    label: lowDataRate
    value: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: BW/2
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: nUpchirps
  id: parameter
  parameters:
    label: nUpchirps
    value: '5'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: GrayDecodeOut
    type: short
  states: {state: disabled}
- name: pad_sink_1_0
  id: pad_sink
  parameters:
    label: SymbolModOut
    type: float
  states: {state: disabled}
- name: pad_sink_1_0_0
  id: pad_sink
  parameters:
    label: AppendPrefixOut
    type: float
  states: {state: disabled}
- name: pad_sink_1_1
  id: pad_sink
  parameters:
    label: Interleave Out
    type: short
  states: {state: disabled}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: Encode Out
    type: byte
  states: {state: disabled}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: Controller Out
    type: byte
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: payloadSize
  id: parameter
  parameters:
    label: payloadSize
    value: '10'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Interleave Out"'
    size: 20*nFrames
    srate: samp_rate
    type: float
    ymax: 2**SF
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"grayDecode Out"'
    size: 20*nFrames
    srate: samp_rate
    type: float
    ymax: 2**SF
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '10'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 20*nFrames*symbolSize
    srate: samp_rate
    type: float
    ymax: BW/samp_rate
    ymin: '-BW/samp_rate'
  states: {state: disabled}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    name: '"Encode Out"'
    size: 24*nFrames
    srate: samp_rate
    type: float
    ymax: 2**8
    ymin: '0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: 8e6
  states: {}
- name: syncwordNumber
  id: parameter
  parameters:
    label: syncwordNumber
    value: '0'
  states: {}

connections:
- [LibreLoRa_AppendPrefix_0, '0', LibreLoRa_FrequencyMod_0, '0']
- [LibreLoRa_AppendPrefix_0, '0', pad_sink_1_0_0, '0']
- [LibreLoRa_AppendPrefix_0, '0', qtgui_time_sink_x_3, '0']
- [LibreLoRa_AppendSilence_0, '0', pad_sink_0, '0']
- [LibreLoRa_BytesToNibbles_0, '0', LibreLoRa_TransmitterController_0, '0']
- [LibreLoRa_CRC16_0, crcOut, LibreLoRa_TransmitterController_0, setCRC]
- [LibreLoRa_Encode_0, '0', LibreLoRa_Interleave_0, '0']
- [LibreLoRa_Encode_0, '0', blocks_uchar_to_float_1, '0']
- [LibreLoRa_Encode_0, '0', pad_sink_2, '0']
- [LibreLoRa_FrequencyMod_0, '0', LibreLoRa_AppendSilence_0, '0']
- [LibreLoRa_FrequencyMod_0, '0', low_pass_filter_0, '0']
- [LibreLoRa_GrayDecode_0, '0', LibreLoRa_SymbolMod_0, '0']
- [LibreLoRa_GrayDecode_0, '0', blocks_short_to_float_0_0, '0']
- [LibreLoRa_GrayDecode_0, '0', pad_sink_1, '0']
- [LibreLoRa_Interleave_0, '0', LibreLoRa_GrayDecode_0, '0']
- [LibreLoRa_Interleave_0, '0', blocks_short_to_float_0, '0']
- [LibreLoRa_Interleave_0, '0', pad_sink_1_1, '0']
- [LibreLoRa_SymbolMod_0, '0', LibreLoRa_AppendPrefix_0, '0']
- [LibreLoRa_SymbolMod_0, '0', pad_sink_1_0, '0']
- [LibreLoRa_SymbolMod_0, '0', qtgui_time_sink_x_3, '1']
- [LibreLoRa_TransmitterController_0, '0', LibreLoRa_Encode_0, '0']
- [LibreLoRa_TransmitterController_0, '0', blocks_uchar_to_float_0, '0']
- [LibreLoRa_TransmitterController_0, '0', pad_sink_2_0, '0']
- [LibreLoRa_TransmitterController_0, transmissionStart, LibreLoRa_AppendSilence_0, start]
- [LibreLoRa_randomize_0, '0', LibreLoRa_BytesToNibbles_0, '0']
- [analog_const_source_x_1, '0', low_pass_filter_0, '0']
- [analog_random_source_x_0, '0', LibreLoRa_CRC16_0, '0']
- [analog_random_source_x_0, '0', LibreLoRa_randomize_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_4, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [pad_source_0, '0', LibreLoRa_CRC16_0, '0']
- [pad_source_0, '0', LibreLoRa_randomize_0, '0']

metadata:
  file_format: 1
