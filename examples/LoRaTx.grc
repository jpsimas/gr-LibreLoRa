options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: LoRaTx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: CR
  id: variable
  parameters:
    value: '1'
  states: {}
- name: CRCPresent
  id: variable
  parameters:
    value: 'True'
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: SFPayload
  id: variable
  parameters:
    value: SF-2 if lowDataRate else SF
  states: {}
- name: frequency_center
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: lowDataRate
  id: variable
  parameters:
    value: 'False'
  states: {}
- name: nExtraNibbles
  id: variable
  parameters:
    value: (SFPayload - (nPayloadNibbles - (SF - 7))%SFPayload)%SFPayload
  states: {}
- name: nPayloadNibbles
  id: variable
  parameters:
    value: 2*(payloadSize + (2 if CRCPresent else 0))
  states: {}
- name: nPayloadSymbols
  id: variable
  parameters:
    value: 8 + (nExtraNibbles + nPayloadNibbles)*(CR + 4)/SFPayload
  states: {}
- name: nUpchirps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: payloadSize
  id: variable
  parameters:
    value: '8'
  states: {}
- name: preambleFrequency
  id: variable
  parameters:
    value: LibreLoRa.getPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: int((2**SF)*OSF)
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: LibreLoRa_AppendPrefix_0
  id: LibreLoRa_AppendPrefix
  parameters:
    payloadSize: int(nPayloadSymbols*symbolSize)
    prefix: preambleFrequency
    type: float
  states: {state: disabled}
- name: LibreLoRa_BytesToNibbles_0
  id: LibreLoRa_BytesToNibbles
  parameters: {}
  states: {}
- name: LibreLoRa_Encode_0
  id: LibreLoRa_Encode
  parameters:
    CR: CR
  states: {}
- name: LibreLoRa_FrequencyMod_0
  id: LibreLoRa_FrequencyMod
  parameters: {}
  states: {state: disabled}
- name: LibreLoRa_GrayDecode_0
  id: LibreLoRa_GrayDecode
  parameters:
    nBits: SF
  states: {}
- name: LibreLoRa_Interleave_0
  id: LibreLoRa_Interleave
  parameters:
    CR: CR
    SF: SF
  states: {}
- name: LibreLoRa_SymbolMod_0
  id: LibreLoRa_SymbolMod
  parameters:
    SF: SF
    symbolSize: symbolSize
  states: {state: disabled}
- name: LibreLoRa_TransmitterController_0
  id: LibreLoRa_TransmitterController
  parameters:
    CR: CR
    CRCpresent: CRCPresent
    SF: SF
    lowDataRate: lowDataRate
    payloadSize: payloadSize
  states: {}
- name: LibreLoRa_randomize_0
  id: LibreLoRa_randomize
  parameters:
    initialState: '255'
    payloadSize: payloadSize
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: numpy.zeros(2*payloadSize)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: BW
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: BW/2
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: frequency_center
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 20*symbolSize
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '10'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [LibreLoRa_AppendPrefix_0, '0', LibreLoRa_FrequencyMod_0, '0']
- [LibreLoRa_AppendPrefix_0, '0', qtgui_time_sink_x_0, '0']
- [LibreLoRa_BytesToNibbles_0, '0', LibreLoRa_TransmitterController_0, '0']
- [LibreLoRa_Encode_0, '0', LibreLoRa_Interleave_0, '0']
- [LibreLoRa_FrequencyMod_0, '0', low_pass_filter_0, '0']
- [LibreLoRa_GrayDecode_0, '0', LibreLoRa_SymbolMod_0, '0']
- [LibreLoRa_GrayDecode_0, '0', blocks_null_sink_0, '0']
- [LibreLoRa_Interleave_0, '0', LibreLoRa_GrayDecode_0, '0']
- [LibreLoRa_SymbolMod_0, '0', LibreLoRa_AppendPrefix_0, '0']
- [LibreLoRa_SymbolMod_0, '0', qtgui_time_sink_x_2, '0']
- [LibreLoRa_TransmitterController_0, '0', LibreLoRa_Encode_0, '0']
- [LibreLoRa_TransmitterController_0, '0', blocks_uchar_to_float_0, '0']
- [LibreLoRa_randomize_0, '0', LibreLoRa_BytesToNibbles_0, '0']
- [analog_const_source_x_1, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', LibreLoRa_randomize_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_vector_source_x_0, '0', LibreLoRa_randomize_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [low_pass_filter_0, '0', osmosdr_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
