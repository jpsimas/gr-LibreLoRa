options:
  parameters:
    author: jp
    category: '[LibreLora]'
    generate_options: hb
    id: DCFT
    output_language: python
    thread_safe_setters: '1'
    title: DCFT
  states: {}

blocks:
- name: chirpWindow
  id: variable
  parameters:
    value: numpy.real(LibreLoRa.getChirpWindow(DFTSize, windowSize,0, numpy.sqrt(1/chirpRate)))*numpy.sqrt(DFTSize/windowSize)
  states: {}
- name: DFTSize
  id: parameter
  parameters:
    value: '2048'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: chirpWindow
    type: complex
    vlen: DFTSize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: DFTSize
    type: complex
  states: {}
- name: chirpRate
  id: parameter
  parameters:
    label: chirpRate
    value: 2**(-11)
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: DFTSize
    forward: 'True'
    shift: 'False'
    type: complex
    window: numpy.ones(DFTSize)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
    vlen: DFTSize
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: 1e6
  states: {}
- name: windowSize
  id: parameter
  parameters:
    value: '32'
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
