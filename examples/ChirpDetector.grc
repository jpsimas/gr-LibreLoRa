options:
  parameters:
    author: jp
    category: '[LibreLoRa]'
    generate_options: hb
    id: ChirpDetector
    output_language: python
    title: ChirpDetector
  states: {}

blocks:
- name: chirpRate
  id: variable
  parameters:
    value: ((BW/samp_rate)**2)*(2**(-SF ))
  states: {}
- name: chirpWindow
  id: variable
  parameters:
    value: numpy.real(LibreLoRa.getChirpWindow(DFTSize, windowSize,0, numpy.sqrt(1/chirpRate)))*numpy.sqrt(DFTSize/windowSize)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: windowSize
  id: variable
  parameters:
    value: DFTSize
  states: {}
- name: BW
  id: parameter
  parameters:
    label: bw
    value: 125e3
  states: {}
- name: DFTSize
  id: parameter
  parameters:
    value: '2048'
  states: {}
- name: LibreLoRa_PowerDetector_0
  id: LibreLoRa_PowerDetector
  parameters:
    decimation: DFTSize
    minoutbuf: int(timeout*samp_rate)
    threshold: threshold
    timeout: timeout
  states: {}
- name: LibreLoRa_ToneDetector_0
  id: LibreLoRa_ToneDetector
  parameters:
    dftsize: DFTSize
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '7'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    minoutbuf: '32'
    vlen: DFTSize
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: chirpWindow
    type: complex
    vlen: DFTSize
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: DFTSize
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: DFTSize
    forward: 'True'
    shift: 'False'
    type: complex
    window: numpy.ones(DFTSize)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: threshold
  id: parameter
  parameters:
    value: '0.5'
  states: {}
- name: timeout
  id: parameter
  parameters:
    value: '5'
  states: {}

connections:
- [LibreLoRa_PowerDetector_0, '0', pad_sink_0, '0']
- [LibreLoRa_ToneDetector_0, '0', LibreLoRa_PowerDetector_0, '1']
- [blocks_complex_to_mag_squared_0, '0', LibreLoRa_ToneDetector_0, '0']
- [blocks_multiply_const_vxx_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', LibreLoRa_PowerDetector_0, '0']
- [pad_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
