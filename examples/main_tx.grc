options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: main_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: frequency_center
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: gain_if_hackrf_db
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '15'
  states: {}
- name: gain_rf_hackrf_db
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '30'
    value: '13'
  states: {}
- name: nFrames
  id: variable
  parameters:
    value: '2'
  states: {}
- name: nUpchirps
  id: variable
  parameters:
    value: '5'
  states: {}
- name: payloadSize
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: int((2**SF)*OSF)
  states: {}
- name: syncWordNumber
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: BW
  id: parameter
  parameters:
    label: BW
    value: 125e3
  states: {}
- name: LibreLoRa_LoRaTaggedStreamToTaggedStream_0
  id: LibreLoRa_LoRaTaggedStreamToTaggedStream
  parameters:
    lengthTagName: payloadSize
  states: {}
- name: LoRaTx_0
  id: LoRaTx
  parameters:
    BW: BW
    CR: '1'
    CRCPresent: 'True'
    SF: SF
    lowDataRate: 'False'
    nUpchirps: nUpchirps
    payloadSize: payloadSize
    samp_rate: samp_rate
    syncwordNumber: syncWordNumber
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1201'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: soapy=0,driver=hackrf
    bb_gain0: '0'
    freq0: frequency_center
    gain0: gain_rf_hackrf_db
    if_gain0: gain_if_hackrf_db
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}

connections:
- [LibreLoRa_LoRaTaggedStreamToTaggedStream_0, '0', LoRaTx_0, '0']
- [LibreLoRa_LoRaTaggedStreamToTaggedStream_0, '0', blocks_tag_debug_0, '0']
- [LoRaTx_0, '0', blocks_throttle_0, '0']
- [LoRaTx_0, '0', osmosdr_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', LibreLoRa_LoRaTaggedStreamToTaggedStream_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
