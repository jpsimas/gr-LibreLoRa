options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: main_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: frequency_center
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: nFrames
  id: variable
  parameters:
    value: '1'
  states: {}
- name: payloadSize
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: int((2**SF)*OSF)
  states: {}
- name: BW
  id: parameter
  parameters:
    label: BW
    value: 125e3
  states: {}
- name: LoRaTx_0
  id: LoRaTx
  parameters:
    BW: BW
    CR: '1'
    CRCPresent: 'True'
    SF: SF
    lowDataRate: 'False'
    nUpchirps: '5'
    payloadSize: payloadSize
    samp_rate: samp_rate
    syncwordNumber: '0'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '1234'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: byte
    vector: numpy.zeros(nFrames*payloadSize)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '20'
    freq0: frequency_center
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:1201
    timeout: '100'
    type: byte
  states: {state: disabled}

connections:
- [LoRaTx_0, '0', blocks_throttle_0, '0']
- [LoRaTx_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_udp_source_0, '0', LoRaTx_0, '0']
- [blocks_vector_source_x_0, '0', LoRaTx_0, '0']
- [zeromq_sub_source_0, '0', LoRaTx_0, '0']

metadata:
  file_format: 1
