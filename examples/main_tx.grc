options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: main_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: frequency_center
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: nFrames
  id: variable
  parameters:
    value: '2'
  states: {}
- name: payloadSize
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 8e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: int((2**SF)*OSF)
  states: {}
- name: BW
  id: parameter
  parameters:
    label: BW
    value: 125e3
  states: {}
- name: LibreLoRa_CRC16_0
  id: LibreLoRa_CRC16
  parameters:
    payloadsize: payloadSize
    polynomial: '0x1021'
    xorout: '0'
  states: {state: disabled}
- name: LoRaTx_0
  id: LoRaTx
  parameters:
    BW: BW
    CR: '1'
    CRCPresent: 'True'
    SF: SF
    lowDataRate: 'False'
    nUpchirps: '5'
    payloadSize: payloadSize
    samp_rate: samp_rate
    syncwordNumber: '0'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '52001'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: hackrf=0
    bb_gain0: '0'
    freq0: frequency_center
    gain0: '0'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Interleave Out"'
    size: 20*nFrames
    srate: samp_rate
    type: float
    ymax: 2**SF
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"grayDecode Out"'
    size: 20*nFrames
    srate: samp_rate
    type: float
    ymax: 2**SF
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: Controller Out
    size: 24*nFrames
    srate: samp_rate
    type: float
    ymax: 2**4
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 20*nFrames*symbolSize
    srate: samp_rate
    type: float
    ymax: BW/samp_rate
    ymin: '-BW/samp_rate'
  states: {}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    marker1: '0'
    name: '"Encode Out"'
    size: 24*nFrames
    srate: samp_rate
    type: float
    ymax: 2**8
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [LibreLoRa_CRC16_0, crcOut, blocks_message_debug_0, print]
- [LoRaTx_0, '0', blocks_throttle_0, '0']
- [LoRaTx_0, '0', osmosdr_sink_0, '0']
- [LoRaTx_0, '1', blocks_short_to_float_0_0, '0']
- [LoRaTx_0, '2', qtgui_time_sink_x_3, '0']
- [LoRaTx_0, '3', qtgui_time_sink_x_3, '1']
- [LoRaTx_0, '4', blocks_short_to_float_0, '0']
- [LoRaTx_0, '5', blocks_uchar_to_float_1, '0']
- [LoRaTx_0, '6', blocks_uchar_to_float_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', LibreLoRa_CRC16_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', LoRaTx_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_socket_pdu_0, pdus, blocks_pdu_to_tagged_stream_0, pdus]
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_4, '0']

metadata:
  file_format: 1
