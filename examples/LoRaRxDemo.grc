options:
  parameters:
    category: '[LibreLoRa]'
    generate_options: hb
    id: LoRaRxDemo
    output_language: python
    title: LoRa Rx Demo
  states: {}

blocks:
- name: DFTSize
  id: variable
  parameters:
    value: int(symbolSize*decimation)
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW))
  states: {}
- name: chirpWindow
  id: variable
  parameters:
    value: numpy.real(LibreLoRa.getChirpWindow(DFTSize, windowSize, SF, symbolSize*decimation))
  states: {}
- name: lowDataRateRequired
  id: variable
  parameters:
    value: ((BW*(2**(-SF))) < 62.5) and (not ignoreLowDataRateRequired)
  states: {}
- name: maxFrameTime
  id: variable
  parameters:
    value: (2**(SF)/BW)*(5 + 8 + 257*2*8/SF)
  states: {}
- name: nUpchirps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: preambleComplex
  id: variable
  parameters:
    value: numpy.exp(1j*2*numpy.pi*OSF*decimation*LibreLoRa.getPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber))
  states: {}
- name: preambleNormalized
  id: variable
  parameters:
    value: LibreLoRa.getNormalizedPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber)
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: int(((2**SF)*OSF)/decimation)
  states: {}
- name: upchirp
  id: variable
  parameters:
    value: numpy.asarray(LibreLoRa.getSymbol(0, SF, symbolSize))
  states: {}
- name: windowSize
  id: variable
  parameters:
    value: int(symbolSize*decimation/4)
  states: {}
- name: BW
  id: parameter
  parameters:
    label: BW
    value: 125e3
  states: {}
- name: LibreLoRa_CRC16_0
  id: LibreLoRa_CRC16
  parameters:
    payloadsize: '0'
    polynomial: '0x1021'
    xorout: '0x0000'
  states: {}
- name: LibreLoRa_ChirpDetector_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTDecim: detectionDecim
    DFTSize: symbolSize*decimation
    SF: SF
    samp_rate: samp_rate
    threshold: detectorThreshold
    timeout: maxFrameTime
  states: {}
- name: LibreLoRa_Correlation_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
    type: float
  states: {}
- name: LibreLoRa_FFTMax_0
  id: LibreLoRa_FFTMax
  parameters:
    DFTSize: DFTSize
    window: chirpWindow
  states: {}
- name: LibreLoRa_NibblesToBytes_0
  id: LibreLoRa_NibblesToBytes
  parameters: {}
  states: {}
- name: LibreLoRa_Remainder_0_0
  id: LibreLoRa_Remainder
  parameters:
    divisor: '1.0'
  states: {}
- name: LibreLoRa_correlationSync_0
  id: LibreLoRa_correlationSync
  parameters:
    SF: SF
    corrMin: '0.8'
    corrStop: '0.6'
    preambleSize: preambleNormalized.size
    symbolSize: symbolSize
    syncWordNumber: syncwordNumber
    type: float
  states: {}
- name: LibreLoRa_decode_0
  id: LibreLoRa_decode
  parameters:
    CR: '4'
  states: {}
- name: LibreLoRa_deinterleave_0
  id: LibreLoRa_deinterleave
  parameters:
    CR: '4'
    SF: '7'
  states: {}
- name: LibreLoRa_grayEncode_0
  id: LibreLoRa_grayEncode
  parameters:
    SF: SF
  states: {}
- name: LibreLoRa_randomize_0
  id: LibreLoRa_randomize
  parameters:
    initialState: '0'
    payloadSize: '0'
  states: {}
- name: LibreLoRa_receiverController_0
  id: LibreLoRa_receiverController
  parameters:
    SF: SF
    lowDataRate: lowDataRate or lowDataRateRequired
  states: {}
- name: LibreLoRa_streamToHistoryVector_0
  id: LibreLoRa_streamToHistoryVector
  parameters:
    decimation: decimation
    nVect: DFTSize
    type: complex
  states: {}
- name: LibreLoRa_symbolDemodNew_0
  id: LibreLoRa_symbolDemodNew
  parameters:
    SF: SF
    symbolSize: symbolSize
    windowSize: int(symbolSize/2)
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '7'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: DFTSize
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: decimation
    type: float
  states: {}
- name: decimation
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: detectionDecim
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: detectorThreshold
  id: parameter
  parameters:
    label: detectorThreshold
    value: '100'
  states: {}
- name: ignoreLowDataRateRequired
  id: parameter
  parameters:
    value: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: lowDataRate
  id: parameter
  parameters:
    label: lowDataRate
    value: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: dataOut
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: freq
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_10
  id: pad_sink
  parameters:
    label: symsGrayOut
    optional: 'True'
    type: short
  states: {}
- name: pad_sink_11
  id: pad_sink
  parameters:
    label: codewords
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_12
  id: pad_sink
  parameters:
    label: nibbles
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_13
  id: pad_sink
  parameters:
    label: randomized bytes
    optional: 'True'
    type: byte
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: corr
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: payloadLengthOut
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: reset
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: detectionOut
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: corrOut
    optional: 'True'
    type: float
  states: {state: disabled}
- name: pad_sink_6
  id: pad_sink
  parameters:
    label: sigOut
    optional: 'True'
    type: float
  states: {state: disabled}
- name: pad_sink_7
  id: pad_sink
  parameters:
    label: crcOut
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_8
  id: pad_sink
  parameters:
    label: sigSync
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_9
  id: pad_sink
  parameters:
    label: syms
    optional: 'True'
    type: short
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: 1e6
  states: {}
- name: syncwordNumber
  id: parameter
  parameters:
    value: '0x00'
  states: {}

connections:
- [LibreLoRa_CRC16_0, crcOut, pad_sink_7, in]
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_streamToHistoryVector_0, '0']
- [LibreLoRa_ChirpDetector_0, detectOut, LibreLoRa_Correlation_0, enable]
- [LibreLoRa_ChirpDetector_0, detectOut, LibreLoRa_FFTMax_0, enable]
- [LibreLoRa_ChirpDetector_0, detectOut, LibreLoRa_correlationSync_0, reset]
- [LibreLoRa_ChirpDetector_0, detectOut, pad_sink_4, in]
- [LibreLoRa_Correlation_0, '0', LibreLoRa_correlationSync_0, '1']
- [LibreLoRa_Correlation_0, '0', pad_sink_2, '0']
- [LibreLoRa_Correlation_0, '0', pad_sink_5, '0']
- [LibreLoRa_Correlation_0, '1', LibreLoRa_correlationSync_0, '0']
- [LibreLoRa_Correlation_0, '1', pad_sink_6, '0']
- [LibreLoRa_Correlation_0, '1', pad_sink_8, '0']
- [LibreLoRa_FFTMax_0, '0', blocks_int_to_float_0, '0']
- [LibreLoRa_NibblesToBytes_0, '0', LibreLoRa_randomize_0, '0']
- [LibreLoRa_NibblesToBytes_0, '0', pad_sink_13, '0']
- [LibreLoRa_Remainder_0_0, '0', blocks_multiply_const_vxx_2, '0']
- [LibreLoRa_correlationSync_0, '0', LibreLoRa_symbolDemodNew_0, '0']
- [LibreLoRa_correlationSync_0, sync, LibreLoRa_Correlation_0, reset]
- [LibreLoRa_correlationSync_0, sync, LibreLoRa_receiverController_0, sync]
- [LibreLoRa_decode_0, '0', LibreLoRa_receiverController_0, '0']
- [LibreLoRa_decode_0, '0', pad_sink_12, '0']
- [LibreLoRa_deinterleave_0, '0', LibreLoRa_decode_0, '0']
- [LibreLoRa_deinterleave_0, '0', pad_sink_11, '0']
- [LibreLoRa_grayEncode_0, '0', LibreLoRa_deinterleave_0, '0']
- [LibreLoRa_grayEncode_0, '0', pad_sink_10, '0']
- [LibreLoRa_randomize_0, '0', LibreLoRa_CRC16_0, '0']
- [LibreLoRa_randomize_0, '0', pad_sink_0, '0']
- [LibreLoRa_receiverController_0, '0', LibreLoRa_NibblesToBytes_0, '0']
- [LibreLoRa_receiverController_0, crc, LibreLoRa_CRC16_0, setXorOut]
- [LibreLoRa_receiverController_0, lfsrStateOut, LibreLoRa_randomize_0, setLfsrState]
- [LibreLoRa_receiverController_0, payloadLength, LibreLoRa_CRC16_0, setPayloadSize]
- [LibreLoRa_receiverController_0, payloadLength, pad_sink_2_0, in]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_decode_0, setCR]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_deinterleave_0, setCR]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_deinterleave_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_grayEncode_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_symbolDemodNew_0, setSF]
- [LibreLoRa_receiverController_0, synchronizerReset, LibreLoRa_ChirpDetector_0, reset]
- [LibreLoRa_receiverController_0, synchronizerReset, LibreLoRa_correlationSync_0, reset]
- [LibreLoRa_receiverController_0, synchronizerReset, pad_sink_3, in]
- [LibreLoRa_receiverController_0, synchronizerSetN, LibreLoRa_correlationSync_0, setNOutputItemsToProduce]
- [LibreLoRa_streamToHistoryVector_0, '0', LibreLoRa_FFTMax_0, '0']
- [LibreLoRa_symbolDemodNew_0, '0', LibreLoRa_grayEncode_0, '0']
- [LibreLoRa_symbolDemodNew_0, '0', pad_sink_9, '0']
- [blocks_int_to_float_0, '0', LibreLoRa_Remainder_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', LibreLoRa_Correlation_0, '0']
- [blocks_multiply_const_vxx_2, '0', pad_sink_1, '0']
- [pad_source_0, '0', LibreLoRa_ChirpDetector_0, '0']

metadata:
  file_format: 1
