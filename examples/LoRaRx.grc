options:
  parameters:
    category: '[Librelora]'
    generate_options: hb
    id: LoRaRx
    output_language: python
    title: LoRa Rx
  states: {}

blocks:
- name: DFTSize
  id: variable
  parameters:
    value: int(symbolSize)
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/BW)
  states: {}
- name: chirpWindow
  id: variable
  parameters:
    value: numpy.real(LibreLoRa.getChirpWindow(DFTSize, windowSize, SF, symbolSize))
  states: {}
- name: chirpWindowTracker
  id: variable
  parameters:
    value: numpy.real(LibreLoRa.getChirpWindow(windowSize, windowSize, SF, symbolSize))
  states: {}
- name: decimation
  id: variable
  parameters:
    value: 1 if (OSF*2**(SF + 1) <= 2**13) else int(OSF*2**(SF + 1 - 13))
  states: {state: disabled}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: lowDataRateRequired
  id: variable
  parameters:
    value: ((BW*(2**(-SF))) < 62.5) and (not ignoreLowDataRateRequired)
  states: {}
- name: maxFrameTime
  id: variable
  parameters:
    value: (2**(SF)/BW)*(5 + 8 + 257*2*8/SF)
  states: {}
- name: nUpchirps
  id: variable
  parameters:
    value: '0'
  states: {}
- name: preambleComplex
  id: variable
  parameters:
    value: numpy.exp(1j*2*numpy.pi*OSF*decimation*LibreLoRa.getPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber))
  states: {}
- name: preambleNormalized
  id: variable
  parameters:
    value: LibreLoRa.getNormalizedPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber)
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: int(((2**SF)*OSF)/decimation)
  states: {}
- name: upchirp
  id: variable
  parameters:
    value: numpy.asarray(LibreLoRa.getSymbol(0, SF, symbolSize))
  states: {}
- name: windowSize
  id: variable
  parameters:
    value: int(symbolSize/4)
  states: {}
- name: BW
  id: parameter
  parameters:
    label: BW
    value: 125e3
  states: {}
- name: LibreLoRa_ArgMaxAbs_0
  id: LibreLoRa_ArgMaxAbs
  parameters:
    vecLength: DFTSize
  states: {state: disabled}
- name: LibreLoRa_CRC16_0
  id: LibreLoRa_CRC16
  parameters:
    polynomial: '0x1021'
    xorout: '0x0000'
  states: {}
- name: LibreLoRa_ChirpDetector_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTSize: symbolSize
    SF: SF
    samp_rate: samp_rate
    threshold: detectorThreshold
    timeout: maxFrameTime
  states: {}
- name: LibreLoRa_Correlation_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
    type: float
  states: {}
- name: LibreLoRa_Correlation_0_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleComplex/numpy.sqrt(preambleComplex.size)
    type: complex
  states: {state: disabled}
- name: LibreLoRa_NibblesToBytes_0
  id: LibreLoRa_NibblesToBytes
  parameters: {}
  states: {}
- name: LibreLoRa_correlationSyncDemod_0
  id: LibreLoRa_correlationSyncDemod
  parameters:
    SF: SF
    corrMin: '0.8'
    corrStop: '0.6'
    preambleSize: preambleNormalized.size
    symbolSize: symbolSize
    syncWordNumber: syncwordNumber
  states: {state: disabled}
- name: LibreLoRa_correlationSync_0
  id: LibreLoRa_correlationSync
  parameters:
    SF: SF
    corrMin: '0.9'
    corrStop: '0.7'
    preambleSize: preambleNormalized.size
    symbolSize: symbolSize
    syncWordNumber: syncwordNumber
    type: float
  states: {}
- name: LibreLoRa_decode_0
  id: LibreLoRa_decode
  parameters:
    CR: '4'
  states: {}
- name: LibreLoRa_deinterleave_0
  id: LibreLoRa_deinterleave
  parameters:
    CR: '4'
    SF: '7'
  states: {}
- name: LibreLoRa_frequencyTrackerN_0
  id: LibreLoRa_frequencyTrackerN
  parameters:
    OSF: OSF
    SF: SF
    mu: 1/(2*OSF) if OSF < 4 else 2/OSF
    type: float
    window: chirpWindowTracker
  states: {state: disabled}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    decimation: decimation
    mu: 1/(2*OSF) if OSF < 4 else 2/OSF
    type: float
  states: {}
- name: LibreLoRa_grayEncode_0
  id: LibreLoRa_grayEncode
  parameters:
    SF: SF
  states: {}
- name: LibreLoRa_randomize_0
  id: LibreLoRa_randomize
  parameters: {}
  states: {}
- name: LibreLoRa_receiverController_0
  id: LibreLoRa_receiverController
  parameters:
    SF: SF
    lowDataRate: lowDataRate or lowDataRateRequired
  states: {}
- name: LibreLoRa_streamToHistoryVector_0
  id: LibreLoRa_streamToHistoryVector
  parameters:
    nVect: DFTSize
    type: complex
  states: {state: disabled}
- name: LibreLoRa_symbolDemodNew_0
  id: LibreLoRa_symbolDemodNew
  parameters:
    OSF: OSF
    SF: SF
    symbolSize: symbolSize
  states: {state: disabled}
- name: LibreLoRa_symbolDemod_0
  id: LibreLoRa_symbolDemod
  parameters:
    SF: SF
    implicit: 'False'
    symbolSize: symbolSize
    type: float
    windowSize: int(symbolSize/2)
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '7'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_2
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: DFTSize
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*numpy.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_4
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*OSF) if OSF < 4 else 2/OSF
    type: float
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: detectorThreshold
  id: parameter
  parameters:
    label: detectorThreshold
    value: '100'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: DFTSize
    forward: 'True'
    nthreads: '4'
    shift: 'False'
    type: complex
    window: chirpWindow
  states: {state: disabled}
- name: ignoreLowDataRateRequired
  id: parameter
  parameters:
    value: 'False'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: lowDataRate
  id: parameter
  parameters:
    label: lowDataRate
    value: 'False'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: dataOut
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: CRCCheckOut
    type: short
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: CRout
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: payloadLengthOut
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: reset
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_4
  id: pad_sink
  parameters:
    label: detectionOut
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: 1e6
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 2/OSF
    type: complex
  states: {state: disabled}
- name: syncwordNumber
  id: parameter
  parameters:
    value: '0x00'
  states: {}

connections:
- [LibreLoRa_ArgMaxAbs_0, '0', blocks_int_to_float_0, '0']
- [LibreLoRa_ArgMaxAbs_0, '1', blocks_null_sink_2, '0']
- [LibreLoRa_CRC16_0, '0', pad_sink_1, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_frequencyTrackerN_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_streamToHistoryVector_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', blocks_delay_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [LibreLoRa_ChirpDetector_0, detectOut, LibreLoRa_Correlation_0, enable]
- [LibreLoRa_ChirpDetector_0, detectOut, pad_sink_4, in]
- [LibreLoRa_Correlation_0, '0', LibreLoRa_correlationSyncDemod_0, '1']
- [LibreLoRa_Correlation_0, '0', LibreLoRa_correlationSync_0, '1']
- [LibreLoRa_Correlation_0, '1', LibreLoRa_correlationSyncDemod_0, '0']
- [LibreLoRa_Correlation_0, '1', LibreLoRa_correlationSync_0, '0']
- [LibreLoRa_Correlation_0_0, '0', LibreLoRa_correlationSync_0, '1']
- [LibreLoRa_Correlation_0_0, '1', LibreLoRa_correlationSync_0, '0']
- [LibreLoRa_NibblesToBytes_0, '0', LibreLoRa_randomize_0, '0']
- [LibreLoRa_correlationSyncDemod_0, '0', LibreLoRa_grayEncode_0, '0']
- [LibreLoRa_correlationSyncDemod_0, sync, LibreLoRa_receiverController_0, sync]
- [LibreLoRa_correlationSync_0, '0', LibreLoRa_symbolDemodNew_0, '0']
- [LibreLoRa_correlationSync_0, '0', LibreLoRa_symbolDemod_0, '0']
- [LibreLoRa_correlationSync_0, sync, LibreLoRa_Correlation_0, reset]
- [LibreLoRa_correlationSync_0, sync, LibreLoRa_receiverController_0, sync]
- [LibreLoRa_decode_0, '0', LibreLoRa_receiverController_0, '0']
- [LibreLoRa_deinterleave_0, '0', LibreLoRa_decode_0, '0']
- [LibreLoRa_frequencyTrackerN_0, '0', LibreLoRa_Correlation_0, '0']
- [LibreLoRa_frequencyTrackerN_0, '0', LibreLoRa_Correlation_0_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_Correlation_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_Correlation_0_0, '0']
- [LibreLoRa_grayEncode_0, '0', LibreLoRa_deinterleave_0, '0']
- [LibreLoRa_randomize_0, '0', LibreLoRa_CRC16_0, '0']
- [LibreLoRa_randomize_0, '0', pad_sink_0, '0']
- [LibreLoRa_receiverController_0, '0', LibreLoRa_NibblesToBytes_0, '0']
- [LibreLoRa_receiverController_0, crc, LibreLoRa_CRC16_0, setXorOut]
- [LibreLoRa_receiverController_0, lfsrStateOut, LibreLoRa_randomize_0, setLfsrState]
- [LibreLoRa_receiverController_0, payloadLength, LibreLoRa_CRC16_0, setPayloadSize]
- [LibreLoRa_receiverController_0, payloadLength, pad_sink_2_0, in]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_decode_0, setCR]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_deinterleave_0, setCR]
- [LibreLoRa_receiverController_0, setCRout, pad_sink_2, in]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_correlationSyncDemod_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_deinterleave_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_grayEncode_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_symbolDemodNew_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_symbolDemod_0, setSF]
- [LibreLoRa_receiverController_0, synchronizerReset, LibreLoRa_ChirpDetector_0, reset]
- [LibreLoRa_receiverController_0, synchronizerReset, LibreLoRa_correlationSyncDemod_0, reset]
- [LibreLoRa_receiverController_0, synchronizerReset, LibreLoRa_correlationSync_0, reset]
- [LibreLoRa_receiverController_0, synchronizerReset, pad_sink_3, in]
- [LibreLoRa_receiverController_0, synchronizerSetN, LibreLoRa_correlationSyncDemod_0, setNOutputItemsToProduce]
- [LibreLoRa_receiverController_0, synchronizerSetN, LibreLoRa_correlationSync_0, setNOutputItemsToProduce]
- [LibreLoRa_streamToHistoryVector_0, '0', fft_vxx_0, '0']
- [LibreLoRa_symbolDemodNew_0, '0', LibreLoRa_grayEncode_0, '0']
- [LibreLoRa_symbolDemod_0, '0', LibreLoRa_grayEncode_0, '0']
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_arg_2, '0', blocks_multiply_const_vxx_4, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_int_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_magphase_to_complex_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', LibreLoRa_Correlation_0, '0']
- [blocks_multiply_const_vxx_4, '0', LibreLoRa_Correlation_0, '0']
- [fft_vxx_0, '0', LibreLoRa_ArgMaxAbs_0, '0']
- [pad_source_0, '0', LibreLoRa_ChirpDetector_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_complex_to_arg_2, '0']

metadata:
  file_format: 1
