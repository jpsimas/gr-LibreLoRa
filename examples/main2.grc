options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: main2
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: DFTSize
  id: variable
  parameters:
    value: int(symbolSize)
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW*decimation))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: alphaPower
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 433e6
  states: {}
- name: chirpWindow
  id: variable
  parameters:
    value: numpy.real(LibreLoRa.getChirpWindow(DFTSize, windowSize, SF, symbolSize))
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: decimationRx
  id: variable
  parameters:
    value: int(symbolSize/128)
  states: {}
- name: detectionDecim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: maxFrameTime
  id: variable
  parameters:
    value: (2**(SF)/BW)*(5 + 8 + 257*2*8/SF)
  states: {}
- name: powerDecim
  id: variable
  parameters:
    value: '10'
  states: {}
- name: powerThreshold
  id: variable
  parameters:
    value: '1e-3'
  states: {}
- name: preambleComplex
  id: variable
  parameters:
    value: numpy.exp(1j*OSF*2*numpy.pi*LibreLoRa.getPreambleFrequency(SF, symbolSize, 0, syncwordNumber))
  states: {}
- name: preambleNormalized
  id: variable
  parameters:
    value: LibreLoRa.getNormalizedPreambleFrequency(SF, symbolSize, 0, syncwordNumber)
  states: {}
- name: preambleNormalizedDecim
  id: variable
  parameters:
    value: LibreLoRa.getNormalizedPreambleFrequency(SF , symbolSize/2, 0, syncwordNumber)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0x0'
  states: {}
- name: windowSize
  id: variable
  parameters:
    value: int(symbolSize/4)
  states: {}
- name: LibreLoRa_ArgMaxAbs_0
  id: LibreLoRa_ArgMaxAbs
  parameters:
    vecLength: DFTSize
  states: {state: disabled}
- name: LibreLoRa_BinSearchFFT_0_0
  id: LibreLoRa_BinSearchFFT
  parameters:
    DFTSize: DFTSize
  states: {state: disabled}
- name: LibreLoRa_ChirpDetector_0
  id: LibreLoRa_ChirpDetector
  parameters:
    BW: BW
    DFTDecim: '1'
    DFTSize: symbolSize
    SF: SF
    samp_rate: samp_rate
    threshold: '200'
    timeout: maxFrameTime
  states: {state: disabled}
- name: LibreLoRa_Correlation_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalizedDecim
    type: float
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleComplex/numpy.linalg.norm(preambleComplex)
    type: complex
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
    type: float
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0_0_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleComplex/numpy.linalg.norm(preambleComplex)
    type: complex
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0_0_1
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
    type: float
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0_0_1_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
    type: float
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0_0_2
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
    type: float
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_1
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
    type: float
  states: {state: disabled}
- name: LibreLoRa_PowerDetector_0
  id: LibreLoRa_PowerDetector
  parameters:
    decimation: powerDecim
    message: pmt.PMT_NIL
    minoutbuf: 2*int(maxFrameTime*samp_rate)
    samp_rate: samp_rate
    threshold: powerThreshold
    timeout: maxFrameTime*1.5
  states: {state: disabled}
- name: LibreLoRa_SelectMax_0
  id: LibreLoRa_SelectMax
  parameters:
    nInputs: '2'
  states: {state: disabled}
- name: LibreLoRa_chirpSource_0
  id: LibreLoRa_chirpSource
  parameters:
    chirpRate: ''
    symbolSize: symbolSize*8
  states: {state: disabled}
- name: LibreLoRa_chirpSource_0_0
  id: LibreLoRa_chirpSource
  parameters:
    chirpRate: '-(2**SF)/(symbolSize*symbolSize)'
    symbolSize: symbolSize*OSF
  states: {state: disabled}
- name: LibreLoRa_chirpSource_0_0_0
  id: LibreLoRa_chirpSource
  parameters:
    chirpRate: (2**SF)/(symbolSize*symbolSize)
    symbolSize: symbolSize*OSF
  states: {state: disabled}
- name: LibreLoRa_convolution_0
  id: LibreLoRa_convolution
  parameters:
    window: numpy.fft.fft(chirpWindow)
  states: {state: disabled}
- name: LibreLoRa_frequencyTrackerNMode_0
  id: LibreLoRa_frequencyTrackerNMode
  parameters:
    OSF: OSF
    SF: SF
    mu: 2/OSF
    nFreqs: symbolSize
    type: float
    window: numpy.real(LibreLoRa.getChirpWindow(3, 3, SF, symbolSize))
  states: {state: disabled}
- name: LibreLoRa_frequencyTrackerN_0_0
  id: LibreLoRa_frequencyTrackerN
  parameters:
    OSF: OSF
    SF: SF
    mu: 1/(2*OSF)
    type: complex
    window: chirpWindow
  states: {state: disabled}
- name: LibreLoRa_frequencyTrackerN_0_0_0
  id: LibreLoRa_frequencyTrackerN
  parameters:
    OSF: OSF
    SF: SF
    mu: 1/OSF
    type: float
    window: chirpWindow
  states: {state: disabled}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    decimation: 8*OSF
    mu: 1/(2*OSF) if OSF < 4 else 2/OSF
    type: float
  states: {state: disabled}
- name: LibreLoRa_frequencyTracker_0_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    decimation: '1'
    mu: 1/(4*OSF)
    type: complex
  states: {state: disabled}
- name: LibreLoRa_slidingDFTMax_0_0
  id: LibreLoRa_slidingDFTMax
  parameters:
    DFTLength: int(symbolSize/4)
    windowSize: int(symbolSize/4)
  states: {state: disabled}
- name: LibreLoRa_slidingDFTMax_1
  id: LibreLoRa_slidingDFTMax
  parameters:
    DFTLength: symbolSize
    windowSize: int(symbolSize/4)
  states: {state: disabled}
- name: LibreLoRa_slidingDFTMax_1_0
  id: LibreLoRa_slidingDFTMax
  parameters:
    DFTLength: symbolSize
    windowSize: int(symbolSize/4)
  states: {state: disabled}
- name: LibreLoRa_slidingDFT_0
  id: LibreLoRa_slidingDFT
  parameters:
    DFTLength: DFTSize
    windowSize: ''
  states: {state: disabled}
- name: LibreLoRa_streamToHistoryVector_0
  id: LibreLoRa_streamToHistoryVector
  parameters:
    decimation: '2'
    nVect: DFTSize
    type: complex
  states: {state: disabled}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: SF
    decimation: decimationRx
    detectionDecim: detectionDecim
    detectorThreshold: '100'
    ignoreLowDataRateRequired: 'True'
    lowDataRate: 'False'
    samp_rate: samp_rate/decimation
    syncwordNumber: syncwordNumber
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_2_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_2_0_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-int((windowSize -1)/2)*(2**SF)/(symbolSize*symbolSize)'
    type: float
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_2_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_2_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_2_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: DFTSize
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_4
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jp/gnuradio/out_sdr_OSF_1_255as_SF_7_crcon_CR_1.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/jp/gnuradio/out_sf_7_8_fs_1M.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: DFTSize
  states: {state: disabled}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: DFTSize
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_magphase_to_complex_0_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_magphase_to_complex_0_2_0_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_magphase_to_complex_0_2_0_0_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: chirpWindow
    type: complex
    vlen: DFTSize
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*numpy.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0_3_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0_3_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*numpy.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_3_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*numpy.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_3_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*numpy.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_3
  id: blocks_multiply_const_vxx
  parameters:
    const: '5e-2'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_3_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '10'
  states: {state: disabled}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: DFTSize
  states: {state: disabled}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '1202'
    tcp_no_delay: 'False'
    type: TCP_SERVER
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_streams_to_vector_1
  id: blocks_streams_to_vector
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: payloadSize
    type: byte
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'True'
    port: '1202'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/decimation
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: LibreLoRa.getSymbol(0, SF + int(2*numpy.log2(OSF)), OSF*symbolSize)
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: DFTSize
    forward: 'True'
    shift: 'False'
    type: complex
    window: chirpWindow
  states: {state: disabled}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    fbtaps: (1, -alphaPower)
    fftaps: (1 - alphaPower)
    oldstyle: 'False'
    type: ffd
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf=0
    bb_gain0: '16'
    clock_source0: internal
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '24'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    legend: 'False'
    name: '"DFTmax output"'
    nconnections: '3'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTrackerN output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTracker<float> output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTracker<gr_complex> output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTrackerN<float> output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTrackerN<float> output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTracker<float> output"'
    nconnections: '4'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_2_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"DFTMax output"'
    nconnections: '4'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_chan: '2'
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_3
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"dft max output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    legend: 'False'
    name: '"DFTmax output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 8)*int(symbolSize/decimationRx))
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_level: '7'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ylabel: Power (dB something)
    ymax: '20'
    ymin: '-10'
  states: {state: disabled}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    entags: 'False'
    name: '"max out"'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_4
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    entags: 'False'
    name: '"norms"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    type: complex
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    fbw: '0.49'
    interp: '1'
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: powerDecim
    interp: '1'
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: center_freq
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LibreLoRa_ArgMaxAbs_0, '0', blocks_int_to_float_0, '0']
- [LibreLoRa_ArgMaxAbs_0, '1', blocks_complex_to_mag_squared_4, '0']
- [LibreLoRa_BinSearchFFT_0_0, '0', blocks_int_to_float_0_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_frequencyTrackerNMode_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_frequencyTrackerN_0_0_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_slidingDFT_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', LibreLoRa_streamToHistoryVector_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', blocks_multiply_xx_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', blocks_multiply_xx_0_0, '0']
- [LibreLoRa_ChirpDetector_0, '0', blocks_multiply_xx_0_0_0, '0']
- [LibreLoRa_ChirpDetector_0, detectOut, blocks_message_debug_1, print]
- [LibreLoRa_Correlation_0, '0', qtgui_time_sink_x_0, '0']
- [LibreLoRa_Correlation_0, '0', qtgui_time_sink_x_0_0_0_2, '2']
- [LibreLoRa_Correlation_0, '0', qtgui_time_sink_x_0_0_0_2_0, '2']
- [LibreLoRa_Correlation_0, '1', qtgui_time_sink_x_0, '1']
- [LibreLoRa_Correlation_0, '1', qtgui_time_sink_x_0_0_0_2, '3']
- [LibreLoRa_Correlation_0, '1', qtgui_time_sink_x_0_0_0_2_0, '3']
- [LibreLoRa_Correlation_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [LibreLoRa_Correlation_0_0, '1', blocks_complex_to_arg_1_0, '0']
- [LibreLoRa_Correlation_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [LibreLoRa_Correlation_0_0_0, '0', qtgui_time_sink_x_0_0_0_2, '0']
- [LibreLoRa_Correlation_0_0_0, '0', qtgui_time_sink_x_0_0_0_2_0, '2']
- [LibreLoRa_Correlation_0_0_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [LibreLoRa_Correlation_0_0_0, '1', qtgui_time_sink_x_0_0_0_2, '1']
- [LibreLoRa_Correlation_0_0_0, '1', qtgui_time_sink_x_0_0_0_2_0, '3']
- [LibreLoRa_Correlation_0_0_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [LibreLoRa_Correlation_0_0_0_0, '1', blocks_complex_to_arg_1, '0']
- [LibreLoRa_Correlation_0_0_0_1, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [LibreLoRa_Correlation_0_0_0_1, '0', qtgui_time_sink_x_0_0_0_2, '2']
- [LibreLoRa_Correlation_0_0_0_1, '1', qtgui_time_sink_x_0_0_0_1, '1']
- [LibreLoRa_Correlation_0_0_0_1, '1', qtgui_time_sink_x_0_0_0_2, '3']
- [LibreLoRa_Correlation_0_0_0_1_0, '0', qtgui_time_sink_x_0_0_0_1_0, '0']
- [LibreLoRa_Correlation_0_0_0_1_0, '0', qtgui_time_sink_x_0_0_0_2, '2']
- [LibreLoRa_Correlation_0_0_0_1_0, '1', qtgui_time_sink_x_0_0_0_1_0, '1']
- [LibreLoRa_Correlation_0_0_0_1_0, '1', qtgui_time_sink_x_0_0_0_2, '3']
- [LibreLoRa_Correlation_0_0_0_2, '0', qtgui_time_sink_x_0_0_0_3, '0']
- [LibreLoRa_Correlation_0_0_0_2, '1', qtgui_time_sink_x_0_0_0_3, '1']
- [LibreLoRa_Correlation_0_1, '0', qtgui_time_sink_x_0_0_0_2_0, '0']
- [LibreLoRa_Correlation_0_1, '1', qtgui_time_sink_x_0_0_0_2_0, '1']
- [LibreLoRa_PowerDetector_0, '0', LoRaRx_0, '0']
- [LibreLoRa_SelectMax_0, '0', LibreLoRa_Correlation_0_0_0_2, '0']
- [LibreLoRa_SelectMax_0, '0', qtgui_time_sink_x_3_0, '0']
- [LibreLoRa_chirpSource_0, '0', blocks_multiply_const_vxx_3, '0']
- [LibreLoRa_chirpSource_0_0, '0', blocks_multiply_xx_0, '1']
- [LibreLoRa_chirpSource_0_0_0, '0', blocks_conjugate_cc_0, '0']
- [LibreLoRa_chirpSource_0_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [LibreLoRa_convolution_0, '0', LibreLoRa_ArgMaxAbs_0, '0']
- [LibreLoRa_convolution_0, '0', blocks_complex_to_mag_squared_1, '0']
- [LibreLoRa_frequencyTrackerNMode_0, '0', LibreLoRa_Correlation_0_0_0_1_0, '0']
- [LibreLoRa_frequencyTrackerN_0_0, '0', LibreLoRa_Correlation_0_0, '0']
- [LibreLoRa_frequencyTrackerN_0_0_0, '0', LibreLoRa_Correlation_0_0_0_1, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_Correlation_0_0_0, '0']
- [LibreLoRa_frequencyTracker_0_0, '0', LibreLoRa_Correlation_0_0_0_0, '0']
- [LibreLoRa_slidingDFTMax_0_0, '0', LibreLoRa_Correlation_0, '0']
- [LibreLoRa_slidingDFTMax_1, '0', blocks_add_xx_2_0, '0']
- [LibreLoRa_slidingDFTMax_1, '1', blocks_complex_to_mag_squared_2, '0']
- [LibreLoRa_slidingDFTMax_1_0, '0', blocks_add_xx_2, '0']
- [LibreLoRa_slidingDFTMax_1_0, '1', blocks_complex_to_mag_squared_3, '0']
- [LibreLoRa_slidingDFT_0, '0', LibreLoRa_convolution_0, '0']
- [LibreLoRa_streamToHistoryVector_0, '0', blocks_multiply_const_vxx_0, '0']
- [LibreLoRa_streamToHistoryVector_0, '0', fft_vxx_0, '0']
- [LoRaRx_0, '0', blocks_tag_debug_0, '0']
- [LoRaRx_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [LoRaRx_0, '0', blocks_tcp_server_sink_0, '0']
- [LoRaRx_0, crcOut, blocks_message_debug_0, print]
- [LoRaRx_0, detectionOut, blocks_message_debug_0, print]
- [LoRaRx_0, reset, LibreLoRa_PowerDetector_0, reset]
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_const_source_x_0_0, '0', blocks_magphase_to_complex_0_0, '0']
- [analog_const_source_x_0_2_0_0, '0', blocks_magphase_to_complex_0_2_0_0, '0']
- [analog_const_source_x_0_2_0_0_0, '0', blocks_magphase_to_complex_0_2_0_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', blocks_add_xx_2, '1']
- [blocks_add_const_vxx_0_0, '0', blocks_multiply_const_vxx_3_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_add_xx_2, '0', blocks_multiply_const_vxx_1_3_0_0, '0']
- [blocks_add_xx_2_0, '0', blocks_multiply_const_vxx_1_3_0_0_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [blocks_complex_to_arg_0_2_0_0, '0', blocks_multiply_const_vxx_1_0_3_0_0, '0']
- [blocks_complex_to_arg_0_2_0_0_0, '0', blocks_multiply_const_vxx_1_0_3_0_0_0, '0']
- [blocks_complex_to_arg_1, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_complex_to_arg_1_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0_1, '0', iir_filter_xxx_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_nlog10_ff_1, '0']
- [blocks_complex_to_mag_squared_2, '0', blocks_streams_to_vector_1, '1']
- [blocks_complex_to_mag_squared_2, '0', qtgui_time_sink_x_4, '1']
- [blocks_complex_to_mag_squared_3, '0', blocks_streams_to_vector_1, '0']
- [blocks_complex_to_mag_squared_3, '0', qtgui_time_sink_x_4, '0']
- [blocks_complex_to_mag_squared_4, '0', qtgui_time_sink_x_0, '2']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_file_source_0, '0', blocks_add_xx_0, '0']
- [blocks_file_source_1, '0', blocks_throttle_1, '0']
- [blocks_int_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_int_to_float_0_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [blocks_magphase_to_complex_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_magphase_to_complex_0_0, '0', blocks_complex_to_arg_0_0, '0']
- [blocks_magphase_to_complex_0_2_0_0, '0', blocks_complex_to_arg_0_2_0_0, '0']
- [blocks_magphase_to_complex_0_2_0_0_0, '0', blocks_complex_to_arg_0_2_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', LibreLoRa_BinSearchFFT_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', fft_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', LibreLoRa_Correlation_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', LibreLoRa_Correlation_0_1, '0']
- [blocks_multiply_const_vxx_1_0_3_0_0, '0', blocks_streams_to_vector_0, '0']
- [blocks_multiply_const_vxx_1_0_3_0_0_0, '0', blocks_streams_to_vector_0, '1']
- [blocks_multiply_const_vxx_1_1, '0', blocks_magphase_to_complex_0_0, '1']
- [blocks_multiply_const_vxx_1_3_0_0, '0', blocks_magphase_to_complex_0_2_0_0, '1']
- [blocks_multiply_const_vxx_1_3_0_0_0, '0', blocks_magphase_to_complex_0_2_0_0_0, '1']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_2_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_multiply_const_vxx_3, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_3_0, '0', blocks_add_xx_2_0, '1']
- [blocks_multiply_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_multiply_xx_0_0, '0', LibreLoRa_slidingDFTMax_1_0, '0']
- [blocks_multiply_xx_0_0_0, '0', LibreLoRa_slidingDFTMax_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_nlog10_ff_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_streams_to_vector_0, '0', LibreLoRa_SelectMax_0, '0']
- [blocks_streams_to_vector_1, '0', LibreLoRa_SelectMax_0, '1']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_socket_pdu_0, pdus]
- [blocks_throttle_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle_0_0, '0', LibreLoRa_slidingDFTMax_0_0, '0']
- [blocks_throttle_1, '0', rational_resampler_xxx_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [dc_blocker_xx_0, '0', LoRaRx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [fft_vxx_0, '0', LibreLoRa_ArgMaxAbs_0, '0']
- [fft_vxx_0, '0', LibreLoRa_convolution_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_1, '0']
- [iir_filter_xxx_0, '0', LibreLoRa_PowerDetector_0, '0']
- [iir_filter_xxx_0, '0', blocks_nlog10_ff_0, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', LibreLoRa_ChirpDetector_0, '0']
- [rational_resampler_xxx_0, '0', LibreLoRa_PowerDetector_0, '1']
- [rational_resampler_xxx_0, '0', LoRaRx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_1, '0', blocks_complex_to_mag_squared_0_1, '0']
- [rtlsdr_source_0, '0', LoRaRx_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
