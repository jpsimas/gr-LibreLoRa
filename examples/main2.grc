options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: main2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: DFTSize
  id: variable
  parameters:
    value: 2*symbolSize
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/(BW*decimation))
  states: {}
- name: SF
  id: variable
  parameters:
    value: '8'
  states: {}
- name: chirpWindow
  id: variable
  parameters:
    value: numpy.real(LibreLoRa.getChirpWindow(DFTSize, windowSize, SF, symbolSize))
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: preambleNormalized
  id: variable
  parameters:
    value: LibreLoRa.getPreambleFrequency(SF, symbolSize, 0, syncwordNumber)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0'
  states: {}
- name: windowSize
  id: variable
  parameters:
    value: int(symbolSize/4)
  states: {}
- name: LibreLoRa_ArgMaxAbs_0
  id: LibreLoRa_ArgMaxAbs
  parameters:
    vecLength: DFTSize
  states: {state: disabled}
- name: LibreLoRa_Correlation_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
  states: {state: disabled}
- name: LibreLoRa_Correlation_0_0_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
  states: {state: disabled}
- name: LibreLoRa_frequencyTrackerN_0_0
  id: LibreLoRa_frequencyTrackerN
  parameters:
    OSF: OSF
    SF: SF
    mu: 1/(2*OSF)
    window: chirpWindow
  states: {state: disabled}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    mu: 1/(2*OSF)
  states: {state: disabled}
- name: LibreLoRa_streamToHistoryVector_0
  id: LibreLoRa_streamToHistoryVector
  parameters:
    nVect: DFTSize
    type: complex
  states: {state: disabled}
- name: LoRaRx_0
  id: LoRaRx
  parameters:
    BW: BW
    SF: SF
    lowDataRate: 'False'
    samp_rate: samp_rate/decimation
    syncwordNumber: syncwordNumber
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jp/gnuradio/out_sdr_OSF_1_a_SF_7_crcon_CR_1.raw
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: DFTSize
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: chirpWindow
    type: complex
    vlen: DFTSize
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*numpy.pi
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'True'
    port: '1202'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/decimation
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: DFTSize
    forward: 'True'
    shift: 'False'
    type: complex
    window: numpy.ones(DFTSize)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"DFTmax output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTrackerN output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.8'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"frequencyTracker output"'
    nconnections: '2'
    size: int((4 + 1/4 + 2**(-SF)  + 5)*symbolSize)
    srate: samp_rate
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '0'
    type: complex
    wintype: firdes.WIN_RECTANGULAR
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation
    interp: '1'
    taps: '[1]'
    type: ccc
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 433e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [LibreLoRa_ArgMaxAbs_0, '0', blocks_int_to_float_0, '0']
- [LibreLoRa_ArgMaxAbs_0, '1', blocks_null_sink_2, '0']
- [LibreLoRa_Correlation_0, '0', qtgui_time_sink_x_0, '0']
- [LibreLoRa_Correlation_0, '1', qtgui_time_sink_x_0, '1']
- [LibreLoRa_Correlation_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [LibreLoRa_Correlation_0_0, '1', qtgui_time_sink_x_0_0, '1']
- [LibreLoRa_Correlation_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [LibreLoRa_Correlation_0_0_0, '1', qtgui_time_sink_x_0_0_0, '1']
- [LibreLoRa_frequencyTrackerN_0_0, '0', LibreLoRa_Correlation_0_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_Correlation_0_0_0, '0']
- [LibreLoRa_streamToHistoryVector_0, '0', blocks_multiply_const_vxx_0, '0']
- [LoRaRx_0, '0', blocks_tcp_server_sink_0, '0']
- [LoRaRx_0, '1', blocks_null_sink_0, '0']
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_int_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_magphase_to_complex_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', fft_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_magphase_to_complex_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', LibreLoRa_Correlation_0, '0']
- [blocks_throttle_0, '0', LibreLoRa_frequencyTrackerN_0_0, '0']
- [blocks_throttle_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [blocks_throttle_0, '0', LibreLoRa_streamToHistoryVector_0, '0']
- [blocks_throttle_0, '0', LoRaRx_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [fft_vxx_0, '0', LibreLoRa_ArgMaxAbs_0, '0']
- [rational_resampler_xxx_0, '0', LibreLoRa_frequencyTrackerN_0_0, '0']
- [rational_resampler_xxx_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [rational_resampler_xxx_0, '0', LibreLoRa_streamToHistoryVector_0, '0']
- [rational_resampler_xxx_0, '0', LoRaRx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
