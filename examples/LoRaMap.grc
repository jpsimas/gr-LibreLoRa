options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: LoRaMap
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: BWmax
  id: variable
  parameters:
    value: BW
  states: {}
- name: DFTSize
  id: variable
  parameters:
    value: int(symbolSizeMax)
  states: {}
- name: SFmax
  id: variable
  parameters:
    value: '12'
  states: {}
- name: SFmin
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nChirpRates
  id: variable
  parameters:
    value: '6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSizeMax
  id: variable
  parameters:
    value: 2**(SFmax)*(samp_rate/BW)/4
  states: {}
- name: symbolSizeMin
  id: variable
  parameters:
    value: 2**(SFmin)*(samp_rate/BW)/4
  states: {}
- name: windowSize
  id: variable
  parameters:
    value: DFTSize
  states: {}
- name: DCFT_0
  id: DCFT
  parameters:
    DFTSize: DFTSize
    chirpRate: ((BWmax/samp_rate)**2)*(2**(-SFmin ))
    samp_rate: samp_rate
    windowSize: windowSize/32
  states: {}
- name: DCFT_0_0
  id: DCFT
  parameters:
    DFTSize: DFTSize
    chirpRate: ((BWmax/samp_rate)**2)*(2**(-(SFmin + 1)))
    samp_rate: samp_rate
    windowSize: windowSize/16
  states: {}
- name: DCFT_0_0_0
  id: DCFT
  parameters:
    DFTSize: DFTSize
    chirpRate: ((BWmax/samp_rate)**2)*(2**(-(SFmin + 3)))
    samp_rate: samp_rate
    windowSize: windowSize/4
  states: {}
- name: DCFT_0_0_1
  id: DCFT
  parameters:
    DFTSize: DFTSize
    chirpRate: ((BWmax/samp_rate)**2)*(2**(-(SFmin + 5)))
    samp_rate: samp_rate
    windowSize: windowSize
  states: {}
- name: DCFT_0_1
  id: DCFT
  parameters:
    DFTSize: DFTSize
    chirpRate: ((BWmax/samp_rate)**2)*(2**(-(SFmin + 2)))
    samp_rate: samp_rate
    windowSize: windowSize/8
  states: {}
- name: DCFT_0_2
  id: DCFT
  parameters:
    DFTSize: DFTSize
    chirpRate: ((BWmax/samp_rate)**2)*(2**(-(SFmin + 4)))
    samp_rate: samp_rate
    windowSize: windowSize/2
  states: {}
- name: LibreLoRa_MatrixSink_1
  id: LibreLoRa_MatrixSink
  parameters:
    maxVal: '10'
    minVal: '0'
    nCols: DFTSize
    nRows: nChirpRates
  states: {state: disabled}
- name: LibreLoRa_chirpSource_0
  id: LibreLoRa_chirpSource
  parameters:
    SF: '8'
    symbolSize: 2**8*BW/samp_rate
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: samp_rate/4
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '7'
    type: short
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: nChirpRates
    type: float
    vlen: DFTSize
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: DFTSize
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: DFTSize
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: DFTSize
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: DFTSize
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: DFTSize
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: DFTSize
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jp/gnuradio/out_sf_11_12_fs_1M.raw
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    num_inputs: nChirpRates
    type: float
    vlen: DFTSize
    vlen_out: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/DFTSize
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/(2*numpy.pi)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: DFTSize
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: DFTSize/(2*numpy.pi)
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_streams_to_stream_0
  id: blocks_streams_to_stream
  parameters:
    num_streams: nChirpRates
    type: float
    vlen: DFTSize
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: DFTSize
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: import_0_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: nChirpRates*DFTSize
    nrows: '128'
    samp_rate: samp_rate
    type: float
    zmax: '80'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    label1: freq
    label2: sf
    label3: power
    nconnections: '3'
    size: '128'
    srate: samp_rate
    tr_chan: '2'
    tr_delay: '10e-6'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '12'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    vlen: DFTSize
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    dc_offset_mode0: '2'
    freq0: 433e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [DCFT_0, '0', blocks_complex_to_mag_squared_0, '0']
- [DCFT_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [DCFT_0_0_0, '0', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [DCFT_0_0_1, '0', blocks_complex_to_mag_squared_0_0_0_0_0_0, '0']
- [DCFT_0_1, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [DCFT_0_2, '0', blocks_complex_to_mag_squared_0_0_0_0_0, '0']
- [LibreLoRa_chirpSource_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_argmax_xx_0, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '1', blocks_add_const_vxx_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', LibreLoRa_MatrixSink_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_argmax_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_max_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_streams_to_stream_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', LibreLoRa_MatrixSink_1, '1']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_argmax_xx_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_max_xx_0, '1']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_streams_to_stream_0, '1']
- [blocks_complex_to_mag_squared_0_0_0, '0', LibreLoRa_MatrixSink_1, '2']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_argmax_xx_0, '2']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_max_xx_0, '2']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_streams_to_stream_0, '2']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', LibreLoRa_MatrixSink_1, '3']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_argmax_xx_0, '3']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_max_xx_0, '3']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_streams_to_stream_0, '3']
- [blocks_complex_to_mag_squared_0_0_0_0_0, '0', LibreLoRa_MatrixSink_1, '4']
- [blocks_complex_to_mag_squared_0_0_0_0_0, '0', blocks_argmax_xx_0, '4']
- [blocks_complex_to_mag_squared_0_0_0_0_0, '0', blocks_max_xx_0, '4']
- [blocks_complex_to_mag_squared_0_0_0_0_0, '0', blocks_streams_to_stream_0, '4']
- [blocks_complex_to_mag_squared_0_0_0_0_0_0, '0', LibreLoRa_MatrixSink_1, '5']
- [blocks_complex_to_mag_squared_0_0_0_0_0_0, '0', blocks_argmax_xx_0, '5']
- [blocks_complex_to_mag_squared_0_0_0_0_0_0, '0', blocks_max_xx_0, '5']
- [blocks_complex_to_mag_squared_0_0_0_0_0_0, '0', blocks_streams_to_stream_0, '5']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_max_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_short_to_float_0, '0', blocks_magphase_to_complex_0, '1']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_streams_to_stream_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_throttle_0, '0', DCFT_0, '0']
- [blocks_throttle_0, '0', DCFT_0_0, '0']
- [blocks_throttle_0, '0', DCFT_0_0_0, '0']
- [blocks_throttle_0, '0', DCFT_0_0_1, '0']
- [blocks_throttle_0, '0', DCFT_0_1, '0']
- [blocks_throttle_0, '0', DCFT_0_2, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [rtlsdr_source_0, '0', DCFT_0, '0']
- [rtlsdr_source_0, '0', DCFT_0_0, '0']
- [rtlsdr_source_0, '0', DCFT_0_0_0, '0']
- [rtlsdr_source_0, '0', DCFT_0_0_1, '0']
- [rtlsdr_source_0, '0', DCFT_0_1, '0']
- [rtlsdr_source_0, '0', DCFT_0_2, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
