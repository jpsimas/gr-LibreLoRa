options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: premabletestRTL
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/BW)
  states: {}
- name: SF
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nUpchirps
  id: variable
  parameters:
    value: '3'
  states: {state: disabled}
- name: preambleSize
  id: variable
  parameters:
    value: symbolSize*(nUpchirps + 2) + int(symbolSize/2)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: upchirp
  id: variable
  parameters:
    value: numpy.asarray(LibreLoRa.getSymbol(0, SF, OSF))
  states: {state: disabled}
- name: LibreLoRa_chirpSource_0
  id: LibreLoRa_chirpSource
  parameters:
    SF: SF
    symbolSize: symbolSize
  states: {state: disabled}
- name: LibreLoRa_correlationSync_0
  id: LibreLoRa_correlationSync
  parameters:
    corrMin: '0.9'
    corrStop: '0.7'
    maxDelay: symbolSize
  states: {}
- name: LibreLoRa_decode_0
  id: LibreLoRa_decode
  parameters:
    CR: '4'
  states: {}
- name: LibreLoRa_deinterleave_0
  id: LibreLoRa_deinterleave
  parameters:
    CR: '4'
    SF: '7'
  states: {}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    mu: 2/OSF
  states: {}
- name: LibreLoRa_grayEncode_0
  id: LibreLoRa_grayEncode
  parameters:
    SF: SF
  states: {}
- name: LibreLoRa_normalizeCorrelation_0
  id: LibreLoRa_normalizeCorrelation
  parameters:
    correlationVectorSize: preambleSize
  states: {state: disabled}
- name: LibreLoRa_preambleDetector_0
  id: LibreLoRa_preambleDetector
  parameters:
    OSF: OSF
    SF: SF
    nUpchirps: '1'
    syncWordNumber: '0x00'
  states: {}
- name: LibreLoRa_readHeader_0
  id: LibreLoRa_readHeader
  parameters:
    SF: SF
  states: {}
- name: LibreLoRa_symbolCorrelator_0
  id: LibreLoRa_symbolCorrelator
  parameters:
    symbol: upchirp
  states: {state: disabled}
- name: LibreLoRa_symbolCorrelator_0_0
  id: LibreLoRa_symbolCorrelator
  parameters:
    symbol: upchirp
  states: {state: disabled}
- name: LibreLoRa_symbolCorrelator_0_0_0
  id: LibreLoRa_symbolCorrelator
  parameters:
    symbol: upchirp
  states: {state: disabled}
- name: LibreLoRa_symbolCorrelator_0_0_0_0
  id: LibreLoRa_symbolCorrelator
  parameters:
    symbol: '-upchirp'
  states: {state: disabled}
- name: LibreLoRa_symbolCorrelator_0_0_0_0_0
  id: LibreLoRa_symbolCorrelator
  parameters:
    symbol: '-upchirp'
  states: {state: disabled}
- name: LibreLoRa_symbolCorrelator_0_0_0_0_0_0
  id: LibreLoRa_symbolCorrelator
  parameters:
    symbol: '-upchirp[0:int(symbolSize/4)]'
  states: {state: disabled}
- name: LibreLoRa_symbolDemod_0
  id: LibreLoRa_symbolDemod
  parameters:
    SF: SF
    symbolSize: (2**SF)*OSF
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jp/Polito/Thesis/lorasim-matlab/sample_data/out_sdr_sf7_fs1000k_length_7bytes_onehot_counting.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: '[0]'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: symbolSize
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '12'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '12'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '7'
    type: byte
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: symbolSize
    type: byte
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"frequencyTracker output"'
    size: symbolSize*OSF
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"correlator Data Out"'
    size: OSF*symbolSize
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Correlation"'
    size: 500*symbolSize
    srate: samp_rate
    type: float
    ylabel: Correlation
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Sum"'
    size: 500*symbolSize
    srate: samp_rate
    type: float
    ylabel: Sum
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Sum Squared"'
    size: 500*symbolSize
    srate: samp_rate
    type: float
    ylabel: Sum Squared
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Sum Squared"'
    size: 500*symbolSize
    srate: samp_rate
    type: float
    ylabel: Sum Squared
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Sum"'
    size: 500*symbolSize
    srate: samp_rate
    type: float
    ylabel: Sum
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Correlation"'
    size: 500*symbolSize
    srate: samp_rate
    type: float
    ylabel: Correlation
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    name: '"Normalized Correlation "'
    size: 500*symbolSize
    srate: samp_rate
    type: float
    ylabel: Correlation
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"correlator Data Out"'
    size: OSF*symbolSize
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: '0.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"sync output"'
    size: 10*symbolSize
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: BW/samp_rate
    ymin: '-BW/samp_rate'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"syncd"'
    size: 10*symbolSize
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: BW/samp_rate
    ymin: '-BW/samp_rate'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Data Nibbles"'
    size: '12'
    srate: samp_rate
    type: float
    ylabel: Byte
    ymax: 2**4 - 1
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Symbols"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Symbol Number
    ymax: 2**SF - 1
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Symbols (Gray Encoded)"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Symbol Number
    ymax: 2**SF - 1
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Codewords"'
    size: '12'
    srate: samp_rate
    type: float
    ylabel: Byte
    ymax: 2**8 - 1
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    nconnections: '5'
    size: '12'
    srate: samp_rate
    type: float
    ymax: '16'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [LibreLoRa_chirpSource_0, '0', blocks_throttle_0, '0']
- [LibreLoRa_correlationSync_0, '0', LibreLoRa_symbolDemod_0, '0']
- [LibreLoRa_correlationSync_0, '0', blocks_vector_to_stream_0, '0']
- [LibreLoRa_correlationSync_0, '1', blocks_vector_to_stream_2, '0']
- [LibreLoRa_decode_0, '0', LibreLoRa_readHeader_0, '0']
- [LibreLoRa_decode_0, '0', blocks_vector_to_stream_1_0, '0']
- [LibreLoRa_deinterleave_0, '0', LibreLoRa_decode_0, '0']
- [LibreLoRa_deinterleave_0, '0', blocks_vector_to_stream_1, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_preambleDetector_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_symbolCorrelator_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', qtgui_time_sink_x_0, '0']
- [LibreLoRa_grayEncode_0, '0', LibreLoRa_deinterleave_0, '0']
- [LibreLoRa_grayEncode_0, '0', blocks_short_to_float_0_0, '0']
- [LibreLoRa_normalizeCorrelation_0, '0', qtgui_time_sink_x_0_0_0_2, '0']
- [LibreLoRa_preambleDetector_0, '0', LibreLoRa_correlationSync_0, '0']
- [LibreLoRa_preambleDetector_0, '0', qtgui_time_sink_x_0_0, '0']
- [LibreLoRa_preambleDetector_0, '1', LibreLoRa_correlationSync_0, '1']
- [LibreLoRa_preambleDetector_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [LibreLoRa_readHeader_0, '0', blocks_uchar_to_float_0_1, '0']
- [LibreLoRa_readHeader_0, '1', blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [LibreLoRa_readHeader_0, '2', blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [LibreLoRa_readHeader_0, '3', blocks_uchar_to_float_0_1_0_0, '0']
- [LibreLoRa_readHeader_0, '4', blocks_vector_to_stream_1_0_0, '0']
- [LibreLoRa_symbolCorrelator_0, '0', LibreLoRa_symbolCorrelator_0_0, '0']
- [LibreLoRa_symbolCorrelator_0, '0', qtgui_time_sink_x_0_0, '0']
- [LibreLoRa_symbolCorrelator_0, '1', LibreLoRa_symbolCorrelator_0_0, '1']
- [LibreLoRa_symbolCorrelator_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [LibreLoRa_symbolCorrelator_0, '2', LibreLoRa_symbolCorrelator_0_0, '2']
- [LibreLoRa_symbolCorrelator_0, '2', qtgui_time_sink_x_0_0_0_0, '0']
- [LibreLoRa_symbolCorrelator_0, '3', LibreLoRa_symbolCorrelator_0_0, '3']
- [LibreLoRa_symbolCorrelator_0, '3', qtgui_time_sink_x_0_0_0_0_0, '0']
- [LibreLoRa_symbolCorrelator_0_0, '0', LibreLoRa_symbolCorrelator_0_0_0, '0']
- [LibreLoRa_symbolCorrelator_0_0, '1', LibreLoRa_symbolCorrelator_0_0_0, '1']
- [LibreLoRa_symbolCorrelator_0_0, '2', LibreLoRa_symbolCorrelator_0_0_0, '2']
- [LibreLoRa_symbolCorrelator_0_0, '3', LibreLoRa_symbolCorrelator_0_0_0, '3']
- [LibreLoRa_symbolCorrelator_0_0_0, '0', LibreLoRa_symbolCorrelator_0_0_0_0, '0']
- [LibreLoRa_symbolCorrelator_0_0_0, '1', LibreLoRa_symbolCorrelator_0_0_0_0, '1']
- [LibreLoRa_symbolCorrelator_0_0_0, '2', LibreLoRa_symbolCorrelator_0_0_0_0, '2']
- [LibreLoRa_symbolCorrelator_0_0_0, '3', LibreLoRa_symbolCorrelator_0_0_0_0, '3']
- [LibreLoRa_symbolCorrelator_0_0_0_0, '0', LibreLoRa_symbolCorrelator_0_0_0_0_0, '0']
- [LibreLoRa_symbolCorrelator_0_0_0_0, '1', LibreLoRa_symbolCorrelator_0_0_0_0_0, '1']
- [LibreLoRa_symbolCorrelator_0_0_0_0, '2', LibreLoRa_symbolCorrelator_0_0_0_0_0, '2']
- [LibreLoRa_symbolCorrelator_0_0_0_0, '3', LibreLoRa_symbolCorrelator_0_0_0_0_0, '3']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0, '0', LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '0']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0, '1', LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '1']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0, '2', LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '2']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0, '3', LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '3']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '1', LibreLoRa_normalizeCorrelation_0, '0']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '1', qtgui_time_sink_x_0_0_0_1, '0']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '2', LibreLoRa_normalizeCorrelation_0, '1']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '2', qtgui_time_sink_x_0_0_0_0_1, '0']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '3', LibreLoRa_normalizeCorrelation_0, '2']
- [LibreLoRa_symbolCorrelator_0_0_0_0_0_0, '3', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [LibreLoRa_symbolDemod_0, '0', LibreLoRa_grayEncode_0, '0']
- [LibreLoRa_symbolDemod_0, '0', blocks_short_to_float_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_short_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_short_to_float_0_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_throttle_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_uchar_to_float_0_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_uchar_to_float_0_1_0, '0', qtgui_time_sink_x_2, '4']
- [blocks_uchar_to_float_0_1_0_0, '0', qtgui_time_sink_x_2, '3']
- [blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_2, '2']
- [blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_vector_source_x_0, '0', LibreLoRa_symbolCorrelator_0, '1']
- [blocks_vector_source_x_0, '0', LibreLoRa_symbolCorrelator_0, '2']
- [blocks_vector_source_x_0, '0', LibreLoRa_symbolCorrelator_0, '3']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_vector_to_stream_1, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_vector_to_stream_1_0_0, '0', blocks_uchar_to_float_0_1_0, '0']
- [blocks_vector_to_stream_2, '0', blocks_uchar_to_float_1, '0']
- [rtlsdr_source_0, '0', blocks_throttle_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
