options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: premabletestRTL
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/BW)
  states: {}
- name: SF
  id: variable
  parameters:
    value: '7'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 0.5e6
  states: {}
- name: LibreLoRa_correlationSync_0
  id: LibreLoRa_correlationSync
  parameters:
    corrStop: '0.7'
    maxDelay: '10240'
    minCorr: '0.8'
  states: {}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    mu: '0.1'
  states: {}
- name: LibreLoRa_preambleDetector_0
  id: LibreLoRa_preambleDetector
  parameters:
    OSF: OSF
    SF: SF
    corrStop: '0.7'
    minCorr: '0.8'
    nUpchirps: '1'
    syncWordNumber: '0x00'
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"frequencyTracker output"'
    size: '100000'
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"preambleDetector Data Out"'
    size: '100000'
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Correlation"'
    size: '100000'
    srate: samp_rate
    type: float
    ylabel: Correlation
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"syncd"'
    size: '100000'
    srate: samp_rate
    type: float
    ylabel: syncd?
    ymax: '0.2'
    ymin: '-0.2'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [LibreLoRa_correlationSync_0, '0', blocks_int_to_float_0, '0']
- [LibreLoRa_correlationSync_0, '1', qtgui_time_sink_x_0_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_preambleDetector_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', qtgui_time_sink_x_0, '0']
- [LibreLoRa_preambleDetector_0, '0', LibreLoRa_correlationSync_0, '0']
- [LibreLoRa_preambleDetector_0, '1', LibreLoRa_correlationSync_0, '1']
- [LibreLoRa_preambleDetector_0, '1', qtgui_time_sink_x_0_0_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [rtlsdr_source_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
