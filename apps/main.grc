options:
  parameters:
    author: jp
    generate_options: qt_gui
    id: premabletestRTL
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: 125e3
  states: {}
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/BW)
  states: {}
- name: SF
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nUpchirps
  id: variable
  parameters:
    value: '0'
  states: {}
- name: preambleNormalized
  id: variable
  parameters:
    value: LibreLoRa.getPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: syncwordNumber
  id: variable
  parameters:
    value: '0x00'
  states: {}
- name: upchirp
  id: variable
  parameters:
    value: numpy.asarray(LibreLoRa.getSymbol(0, SF, OSF))
  states: {}
- name: LibreLoRa_CRC16_0
  id: LibreLoRa_CRC16
  parameters:
    initial: '0x00'
    polynomial: '0x1021'
  states: {}
- name: LibreLoRa_Correlation_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
  states: {}
- name: LibreLoRa_NibblesToBytes_0
  id: LibreLoRa_NibblesToBytes
  parameters: {}
  states: {}
- name: LibreLoRa_chirpSource_0
  id: LibreLoRa_chirpSource
  parameters:
    SF: SF
    symbolSize: symbolSize
  states: {state: disabled}
- name: LibreLoRa_correlationSync_0
  id: LibreLoRa_correlationSync
  parameters:
    corrMin: '0.9'
    corrStop: '0.7'
    symbolSize: symbolSize
  states: {}
- name: LibreLoRa_decode_0
  id: LibreLoRa_decode
  parameters:
    CR: '4'
  states: {}
- name: LibreLoRa_deinterleave_0
  id: LibreLoRa_deinterleave
  parameters:
    CR: '4'
    SF: '7'
  states: {}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    mu: 1/OSF
  states: {}
- name: LibreLoRa_grayEncode_0
  id: LibreLoRa_grayEncode
  parameters:
    SF: SF
  states: {}
- name: LibreLoRa_preambleDetector_0
  id: LibreLoRa_preambleDetector
  parameters:
    OSF: OSF
    SF: SF
    nUpchirps: '1'
    syncWordNumber: '0x00'
  states: {state: disabled}
- name: LibreLoRa_randomize_0
  id: LibreLoRa_randomize
  parameters: {}
  states: {}
- name: LibreLoRa_readHeader_0
  id: LibreLoRa_readHeader
  parameters:
    SF: SF
  states: {state: disabled}
- name: LibreLoRa_receiverController_0
  id: LibreLoRa_receiverController
  parameters:
    SF: SF
    synchronizer: self.LibreLoRa_correlationSync_0
  states: {}
- name: LibreLoRa_symbolDemod_0
  id: LibreLoRa_symbolDemod
  parameters:
    SF: SF
    implicit: 'False'
    symbolSize: (2**SF)*OSF
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/jp/Code/C++/LibreLoRa/apps/nibbles.raw
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jp/Polito/Thesis/lorasim-matlab/sample_data/out_sdr_sf7_fs1000k_length_5bytes_onehot_counting.raw
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    ipaddr: 127.0.0.1
    noblock: 'True'
    port: '1202'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_2_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_udp_sink_1
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '1202'
    psize: '257'
    type: byte
    vlen: '1'
  states: {state: disabled}
- name: blocks_vector_to_stream_3
  id: blocks_vector_to_stream
  parameters:
    num_items: '7'
    type: byte
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"frequencyTracker output"'
    size: symbolSize*OSF
    srate: samp_rate
    type: float
    ylabel: Frequency
    ymax: '0.5'
    ymin: '-0.5'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: data
    label2: corr
    name: '"Correlation"'
    nconnections: '2'
    size: 500*symbolSize
    srate: samp_rate
    tr_chan: '1'
    tr_level: '0.9'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
    ylabel: Correlation
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 0,1,1,1
    name: '"syncd"'
    size: '20'
    srate: samp_rate
    type: float
    update_time: 1/samp_rate
    ylabel: Frequency
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Data Nibbles"'
    size: SF
    srate: samp_rate
    type: float
    ylabel: Byte
    ymax: 2**4 - 1
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Symbols"'
    size: '32'
    srate: samp_rate
    type: float
    ylabel: Symbol Number
    ymax: 2**SF - 1
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Symbols (Gray Encoded)"'
    size: '32'
    srate: samp_rate
    type: float
    ylabel: Symbol Number
    ymax: 2**SF - 1
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Codewords"'
    size: SF
    srate: samp_rate
    type: float
    ylabel: Byte
    ymax: 2**8 - 1
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: Payload Length
    label2: CRC Present
    label3: CR
    label4: CheckSum Pass
    name: '"Header Fields"'
    nconnections: '5'
    size: SF
    srate: samp_rate
    style2: '2'
    type: float
    ymax: '16'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    name: '"Data in Header"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_3_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Payload Nibbles"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 0,0,1,1
    name: '"sync output"'
    update_time: 1/samp_rate
    vlen: symbolSize
    x_start: '0'
    x_step: '1.0'
    ymax: 0.5/OSF
    ymin: '-0.5/OSF'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 433e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [LibreLoRa_CRC16_0, '0', blocks_null_sink_0, '0']
- [LibreLoRa_Correlation_0, '0', LibreLoRa_correlationSync_0, '1']
- [LibreLoRa_Correlation_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [LibreLoRa_NibblesToBytes_0, '0', LibreLoRa_randomize_0, '0']
- [LibreLoRa_chirpSource_0, '0', blocks_throttle_0, '0']
- [LibreLoRa_correlationSync_0, '0', LibreLoRa_symbolDemod_0, '0']
- [LibreLoRa_correlationSync_0, '0', qtgui_vector_sink_f_0, '0']
- [LibreLoRa_correlationSync_0, '1', LibreLoRa_receiverController_0, '1']
- [LibreLoRa_correlationSync_0, '1', blocks_uchar_to_float_1, '0']
- [LibreLoRa_decode_0, '0', LibreLoRa_readHeader_0, '0']
- [LibreLoRa_decode_0, '0', LibreLoRa_receiverController_0, '0']
- [LibreLoRa_decode_0, '0', blocks_uchar_to_float_0, '0']
- [LibreLoRa_deinterleave_0, '0', LibreLoRa_decode_0, '0']
- [LibreLoRa_deinterleave_0, '0', blocks_uchar_to_float_0_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_Correlation_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_correlationSync_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', qtgui_time_sink_x_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [LibreLoRa_grayEncode_0, '0', LibreLoRa_deinterleave_0, '0']
- [LibreLoRa_grayEncode_0, '0', blocks_short_to_float_0_0, '0']
- [LibreLoRa_randomize_0, '0', LibreLoRa_CRC16_0, '0']
- [LibreLoRa_randomize_0, '0', blocks_file_sink_0, '0']
- [LibreLoRa_randomize_0, '0', blocks_tcp_server_sink_0, '0']
- [LibreLoRa_randomize_0, '0', blocks_udp_sink_1, '0']
- [LibreLoRa_readHeader_0, '0', blocks_uchar_to_float_0_1, '0']
- [LibreLoRa_readHeader_0, '1', blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [LibreLoRa_readHeader_0, '2', blocks_uchar_to_float_0_1_0_0_0_0_0_0_0_0_0_0_0_0_0_0_0, '0']
- [LibreLoRa_readHeader_0, '3', blocks_uchar_to_float_0_1_0_0, '0']
- [LibreLoRa_readHeader_0, '4', blocks_vector_to_stream_3, '0']
- [LibreLoRa_receiverController_0, '0', LibreLoRa_NibblesToBytes_0, '0']
- [LibreLoRa_receiverController_0, crc, LibreLoRa_CRC16_0, setInitial]
- [LibreLoRa_receiverController_0, lfsrStateOut, LibreLoRa_randomize_0, setLfsrState]
- [LibreLoRa_receiverController_0, payloadLength, LibreLoRa_CRC16_0, setPayloadSize]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_decode_0, setCR]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_deinterleave_0, setCR]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_deinterleave_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_grayEncode_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_symbolDemod_0, setSF]
- [LibreLoRa_receiverController_0, synchronizerReset, LibreLoRa_correlationSync_0, reset]
- [LibreLoRa_receiverController_0, synchronizerSetN, LibreLoRa_correlationSync_0, setNOutputItemsToProduce]
- [LibreLoRa_symbolDemod_0, '0', LibreLoRa_grayEncode_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_3_0, '0']
- [rtlsdr_source_0, '0', LibreLoRa_frequencyTracker_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
