options:
  parameters:
    category: '[Librelora]'
    generate_options: hb
    id: LoRaRx
    output_language: python
    title: LoRa Rx
  states: {}

blocks:
- name: OSF
  id: variable
  parameters:
    value: round(samp_rate/BW)
  states: {}
- name: nUpchirps
  id: variable
  parameters:
    value: '0'
  states: {}
- name: preambleNormalized
  id: variable
  parameters:
    value: LibreLoRa.getPreambleFrequency(SF, symbolSize, nUpchirps, syncwordNumber)
  states: {}
- name: symbolSize
  id: variable
  parameters:
    value: (2**SF)*OSF
  states: {}
- name: upchirp
  id: variable
  parameters:
    value: numpy.asarray(LibreLoRa.getSymbol(0, SF, OSF))
  states: {}
- name: BW
  id: parameter
  parameters:
    label: BW
    value: 125e3
  states: {}
- name: LibreLoRa_CRC16_0
  id: LibreLoRa_CRC16
  parameters:
    polynomial: '0x1021'
    xorout: '0x0000'
  states: {}
- name: LibreLoRa_Correlation_0
  id: LibreLoRa_Correlation
  parameters:
    symbol: preambleNormalized
  states: {}
- name: LibreLoRa_NibblesToBytes_0
  id: LibreLoRa_NibblesToBytes
  parameters: {}
  states: {}
- name: LibreLoRa_correlationSync_0
  id: LibreLoRa_correlationSync
  parameters:
    corrMin: '0.9'
    corrStop: '0.7'
    symbolSize: symbolSize
  states: {}
- name: LibreLoRa_decode_0
  id: LibreLoRa_decode
  parameters:
    CR: '4'
  states: {}
- name: LibreLoRa_deinterleave_0
  id: LibreLoRa_deinterleave
  parameters:
    CR: '4'
    SF: '7'
  states: {}
- name: LibreLoRa_frequencyTracker_0
  id: LibreLoRa_frequencyTracker
  parameters:
    OSF: OSF
    SF: SF
    mu: 1/OSF
  states: {}
- name: LibreLoRa_grayEncode_0
  id: LibreLoRa_grayEncode
  parameters:
    SF: SF
  states: {}
- name: LibreLoRa_randomize_0
  id: LibreLoRa_randomize
  parameters: {}
  states: {}
- name: LibreLoRa_receiverController_0
  id: LibreLoRa_receiverController
  parameters:
    SF: SF
    synchronizer: self.LibreLoRa_correlationSync_0
  states: {}
- name: LibreLoRa_symbolDemod_0
  id: LibreLoRa_symbolDemod
  parameters:
    SF: SF
    implicit: 'False'
    symbolSize: (2**SF)*OSF
  states: {}
- name: SF
  id: parameter
  parameters:
    label: SF
    value: '7'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import LibreLoRa
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: dataOut
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: CRCCheckOut
    type: short
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: 1e6
  states: {}
- name: syncwordNumber
  id: parameter
  parameters:
    value: '0x00'
  states: {}

connections:
- [LibreLoRa_CRC16_0, '0', pad_sink_1, '0']
- [LibreLoRa_Correlation_0, '0', LibreLoRa_correlationSync_0, '1']
- [LibreLoRa_NibblesToBytes_0, '0', LibreLoRa_randomize_0, '0']
- [LibreLoRa_correlationSync_0, '0', LibreLoRa_symbolDemod_0, '0']
- [LibreLoRa_correlationSync_0, '1', LibreLoRa_receiverController_0, '1']
- [LibreLoRa_decode_0, '0', LibreLoRa_receiverController_0, '0']
- [LibreLoRa_deinterleave_0, '0', LibreLoRa_decode_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_Correlation_0, '0']
- [LibreLoRa_frequencyTracker_0, '0', LibreLoRa_correlationSync_0, '0']
- [LibreLoRa_grayEncode_0, '0', LibreLoRa_deinterleave_0, '0']
- [LibreLoRa_randomize_0, '0', LibreLoRa_CRC16_0, '0']
- [LibreLoRa_randomize_0, '0', pad_sink_0, '0']
- [LibreLoRa_receiverController_0, '0', LibreLoRa_NibblesToBytes_0, '0']
- [LibreLoRa_receiverController_0, crc, LibreLoRa_CRC16_0, setXorOut]
- [LibreLoRa_receiverController_0, lfsrStateOut, LibreLoRa_randomize_0, setLfsrState]
- [LibreLoRa_receiverController_0, payloadLength, LibreLoRa_CRC16_0, setPayloadSize]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_decode_0, setCR]
- [LibreLoRa_receiverController_0, setCRout, LibreLoRa_deinterleave_0, setCR]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_deinterleave_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_grayEncode_0, setSF]
- [LibreLoRa_receiverController_0, setSFout, LibreLoRa_symbolDemod_0, setSF]
- [LibreLoRa_receiverController_0, synchronizerReset, LibreLoRa_correlationSync_0, reset]
- [LibreLoRa_receiverController_0, synchronizerSetN, LibreLoRa_correlationSync_0, setNOutputItemsToProduce]
- [LibreLoRa_symbolDemod_0, '0', LibreLoRa_grayEncode_0, '0']
- [pad_source_0, '0', LibreLoRa_frequencyTracker_0, '0']

metadata:
  file_format: 1
